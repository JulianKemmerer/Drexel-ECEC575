*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2011, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *     NGLibraryCreator, v2010.08-HR32-SP3-2010-08-05 - build 1009061800      *
* *                                                                            *
* ******************************************************************************
*
*
* Running on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr).
* Local time is now Tue, 4 Jan 2011, 14:44:41.
* Main process id is 1680.
*
********************************************************************************
*                                                                              *
* Cellname:   LS_LHEN_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LHEN_X4 VDD VSS A VDDL ISOLN Z
*.PININFO VDD:P VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M9 N_VDDL_M0_d N_A_M0_g N_4_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=9e-08
M_M10 N_6_M1_d N_4_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=9e-08
M_M11 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=9e-08
M_M12 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=9e-08
M_M13 N_10_M4_d N_ISOLN_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1e-07
M_M14 N_VDD_M5_d N_8_M5_g N_10_M4_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1e-07
M_M15 N_Z_M6_d N_10_M6_g N_VDD_M5_d N_VDD_M2_b PMOS_VTL L=5e-08 W=5.9e-07
M_M0 N_VSS_M7_d N_A_M7_g N_4_M7_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M8_d N_4_M8_g N_VSS_M7_d N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M2 12 N_ISOLN_M9_g N_VSS_M9_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_7_M10_d N_6_M10_g 12 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M4 13 N_4_M11_g N_8_M11_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M5 N_VSS_M12_d N_ISOLN_M12_g 13 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M6 14 N_ISOLN_M13_g N_10_M13_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M7 N_VSS_M14_d N_8_M14_g 14 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M8 N_Z_M15_d N_10_M15_g N_VSS_M14_d N_VSS_M7_b NMOS_VTL L=5e-08 W=3.5e-07
C_x_PM_LS_LHEN_X4%VDD_c0 x_PM_LS_LHEN_X4%VDD_51 VSS 0.0273284f
C_x_PM_LS_LHEN_X4%VDD_c1 x_PM_LS_LHEN_X4%VDD_48 VSS 0.0029494f
C_x_PM_LS_LHEN_X4%VDD_c2 x_PM_LS_LHEN_X4%VDD_47 VSS 0.0029494f
C_x_PM_LS_LHEN_X4%VDD_c3 x_PM_LS_LHEN_X4%VDD_46 VSS 0.00564441f
C_x_PM_LS_LHEN_X4%VDD_c4 x_PM_LS_LHEN_X4%VDD_45 VSS 0.0108319f
C_x_PM_LS_LHEN_X4%VDD_c5 x_PM_LS_LHEN_X4%VDD_44 VSS 0.2334f
C_x_PM_LS_LHEN_X4%VDD_c6 x_PM_LS_LHEN_X4%VDD_35 VSS 0.261567f
C_x_PM_LS_LHEN_X4%VDD_c7 N_VDD_M5_d VSS 0.0390005f
C_x_PM_LS_LHEN_X4%VDD_c8 x_PM_LS_LHEN_X4%VDD_27 VSS 0.026785f
C_x_PM_LS_LHEN_X4%VDD_c9 N_VDD_M4_s VSS 0.0235568f
C_x_PM_LS_LHEN_X4%VDD_c10 x_PM_LS_LHEN_X4%VDD_21 VSS 0.038264f
C_x_PM_LS_LHEN_X4%VDD_c11 N_VDD_M2_d VSS 0.0448495f
C_x_PM_LS_LHEN_X4%VDD_c12 x_PM_LS_LHEN_X4%VDD_15 VSS 0.123228f
C_x_PM_LS_LHEN_X4%VDD_c13 x_PM_LS_LHEN_X4%VDD_14 VSS 0.0192462f
C_x_PM_LS_LHEN_X4%VDD_c14 x_PM_LS_LHEN_X4%VDD_10 VSS 0.706493f
R_x_PM_LS_LHEN_X4%VDD_r15 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_51 0.13879
R_x_PM_LS_LHEN_X4%VDD_r16 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_45 0.138595
R_x_PM_LS_LHEN_X4%VDD_r17 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_44 0.138985
R_x_PM_LS_LHEN_X4%VDD_r18 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_35 0.13879
R_x_PM_LS_LHEN_X4%VDD_r19 x_PM_LS_LHEN_X4%VDD_35 VDD 3.84471
R_x_PM_LS_LHEN_X4%VDD_r20 x_PM_LS_LHEN_X4%VDD_34 x_PM_LS_LHEN_X4%VDD_48 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r21 x_PM_LS_LHEN_X4%VDD_51 x_PM_LS_LHEN_X4%VDD_34 0.659412
R_x_PM_LS_LHEN_X4%VDD_r22 x_PM_LS_LHEN_X4%VDD_29 x_PM_LS_LHEN_X4%VDD_48 0.145286
R_x_PM_LS_LHEN_X4%VDD_r23 x_PM_LS_LHEN_X4%VDD_29 N_VDD_M5_d 0.800714
R_x_PM_LS_LHEN_X4%VDD_r24 x_PM_LS_LHEN_X4%VDD_28 x_PM_LS_LHEN_X4%VDD_47 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r25 x_PM_LS_LHEN_X4%VDD_27 x_PM_LS_LHEN_X4%VDD_48 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r26 x_PM_LS_LHEN_X4%VDD_27 x_PM_LS_LHEN_X4%VDD_28 0.692941
R_x_PM_LS_LHEN_X4%VDD_r27 x_PM_LS_LHEN_X4%VDD_23 x_PM_LS_LHEN_X4%VDD_47 0.145286
R_x_PM_LS_LHEN_X4%VDD_r28 x_PM_LS_LHEN_X4%VDD_23 N_VDD_M4_s 0.800714
R_x_PM_LS_LHEN_X4%VDD_r29 x_PM_LS_LHEN_X4%VDD_22 x_PM_LS_LHEN_X4%VDD_46 0.132285
R_x_PM_LS_LHEN_X4%VDD_r30 x_PM_LS_LHEN_X4%VDD_21 x_PM_LS_LHEN_X4%VDD_47 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r31 x_PM_LS_LHEN_X4%VDD_21 x_PM_LS_LHEN_X4%VDD_22 0.961176
R_x_PM_LS_LHEN_X4%VDD_r32 x_PM_LS_LHEN_X4%VDD_17 x_PM_LS_LHEN_X4%VDD_46 0.0680382
R_x_PM_LS_LHEN_X4%VDD_r33 x_PM_LS_LHEN_X4%VDD_17 N_VDD_M2_d 0.344815
R_x_PM_LS_LHEN_X4%VDD_r34 x_PM_LS_LHEN_X4%VDD_15 x_PM_LS_LHEN_X4%VDD_46 0.132285
R_x_PM_LS_LHEN_X4%VDD_r35 x_PM_LS_LHEN_X4%VDD_15 x_PM_LS_LHEN_X4%VDD_45 3.21882
R_x_PM_LS_LHEN_X4%VDD_r36 x_PM_LS_LHEN_X4%VDD_14 N_VDD_M2_b 0.140282
R_x_PM_LS_LHEN_X4%VDD_r37 x_PM_LS_LHEN_X4%VDD_44 x_PM_LS_LHEN_X4%VDD_14 7.68941
R_x_PM_LS_LHEN_X4%VDD_r38 x_PM_LS_LHEN_X4%VDD_10 VDD 11.0647
C_x_PM_LS_LHEN_X4%VSS_c0 x_PM_LS_LHEN_X4%VSS_57 VSS 0.00564441f
C_x_PM_LS_LHEN_X4%VSS_c1 x_PM_LS_LHEN_X4%VSS_56 VSS 0.00283507f
C_x_PM_LS_LHEN_X4%VSS_c2 x_PM_LS_LHEN_X4%VSS_55 VSS 0.00283861f
C_x_PM_LS_LHEN_X4%VSS_c3 x_PM_LS_LHEN_X4%VSS_54 VSS 0.00293741f
C_x_PM_LS_LHEN_X4%VSS_c4 x_PM_LS_LHEN_X4%VSS_52 VSS 0.2334f
C_x_PM_LS_LHEN_X4%VSS_c5 N_VSS_M7_b VSS 0.261566f
C_x_PM_LS_LHEN_X4%VSS_c6 x_PM_LS_LHEN_X4%VSS_42 VSS 0.025263f
C_x_PM_LS_LHEN_X4%VSS_c7 N_VSS_M14_d VSS 0.044101f
C_x_PM_LS_LHEN_X4%VSS_c8 x_PM_LS_LHEN_X4%VSS_36 VSS 0.0418001f
C_x_PM_LS_LHEN_X4%VSS_c9 N_VSS_M12_d VSS 0.0417755f
C_x_PM_LS_LHEN_X4%VSS_c10 x_PM_LS_LHEN_X4%VSS_28 VSS 0.0913087f
C_x_PM_LS_LHEN_X4%VSS_c11 N_VSS_M9_s VSS 0.048479f
C_x_PM_LS_LHEN_X4%VSS_c12 x_PM_LS_LHEN_X4%VSS_22 VSS 0.0334138f
C_x_PM_LS_LHEN_X4%VSS_c13 N_VSS_M7_d VSS 0.0412798f
C_x_PM_LS_LHEN_X4%VSS_c14 x_PM_LS_LHEN_X4%VSS_17 VSS 0.0106021f
C_x_PM_LS_LHEN_X4%VSS_c15 x_PM_LS_LHEN_X4%VSS_16 VSS 0.0548055f
C_x_PM_LS_LHEN_X4%VSS_c16 x_PM_LS_LHEN_X4%VSS_13 VSS 0.706493f
C_x_PM_LS_LHEN_X4%VSS_c17 x_PM_LS_LHEN_X4%VSS_12 VSS 0.0192462f
R_x_PM_LS_LHEN_X4%VSS_r18 N_VSS_M7_b x_PM_LS_LHEN_X4%VSS_52 0.138985
R_x_PM_LS_LHEN_X4%VSS_r19 x_PM_LS_LHEN_X4%VSS_43 x_PM_LS_LHEN_X4%VSS_57 0.132285
R_x_PM_LS_LHEN_X4%VSS_r20 N_VSS_M7_b x_PM_LS_LHEN_X4%VSS_42 0.13879
R_x_PM_LS_LHEN_X4%VSS_r21 x_PM_LS_LHEN_X4%VSS_42 x_PM_LS_LHEN_X4%VSS_43 0.592353
R_x_PM_LS_LHEN_X4%VSS_r22 x_PM_LS_LHEN_X4%VSS_38 x_PM_LS_LHEN_X4%VSS_57 0.0680382
R_x_PM_LS_LHEN_X4%VSS_r23 x_PM_LS_LHEN_X4%VSS_38 N_VSS_M14_d 0.358889
R_x_PM_LS_LHEN_X4%VSS_r24 x_PM_LS_LHEN_X4%VSS_37 x_PM_LS_LHEN_X4%VSS_56 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r25 x_PM_LS_LHEN_X4%VSS_36 x_PM_LS_LHEN_X4%VSS_57 0.132285
R_x_PM_LS_LHEN_X4%VSS_r26 x_PM_LS_LHEN_X4%VSS_36 x_PM_LS_LHEN_X4%VSS_37 0.961176
R_x_PM_LS_LHEN_X4%VSS_r27 x_PM_LS_LHEN_X4%VSS_32 x_PM_LS_LHEN_X4%VSS_56 0.145286
R_x_PM_LS_LHEN_X4%VSS_r28 x_PM_LS_LHEN_X4%VSS_32 N_VSS_M12_d 0.990714
R_x_PM_LS_LHEN_X4%VSS_r29 x_PM_LS_LHEN_X4%VSS_29 x_PM_LS_LHEN_X4%VSS_55 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r30 x_PM_LS_LHEN_X4%VSS_29 VSS 0.793529
R_x_PM_LS_LHEN_X4%VSS_r31 x_PM_LS_LHEN_X4%VSS_28 x_PM_LS_LHEN_X4%VSS_56 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r32 x_PM_LS_LHEN_X4%VSS_28 VSS 1.06176
R_x_PM_LS_LHEN_X4%VSS_r33 x_PM_LS_LHEN_X4%VSS_24 x_PM_LS_LHEN_X4%VSS_55 0.145286
R_x_PM_LS_LHEN_X4%VSS_r34 x_PM_LS_LHEN_X4%VSS_24 N_VSS_M9_s 1.045
R_x_PM_LS_LHEN_X4%VSS_r35 x_PM_LS_LHEN_X4%VSS_23 x_PM_LS_LHEN_X4%VSS_54 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r36 x_PM_LS_LHEN_X4%VSS_22 x_PM_LS_LHEN_X4%VSS_55 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r37 x_PM_LS_LHEN_X4%VSS_22 x_PM_LS_LHEN_X4%VSS_23 0.670588
R_x_PM_LS_LHEN_X4%VSS_r38 x_PM_LS_LHEN_X4%VSS_18 x_PM_LS_LHEN_X4%VSS_54 0.145286
R_x_PM_LS_LHEN_X4%VSS_r39 x_PM_LS_LHEN_X4%VSS_18 N_VSS_M7_d 0.637857
R_x_PM_LS_LHEN_X4%VSS_r40 N_VSS_M7_b x_PM_LS_LHEN_X4%VSS_17 0.138595
R_x_PM_LS_LHEN_X4%VSS_r41 x_PM_LS_LHEN_X4%VSS_16 x_PM_LS_LHEN_X4%VSS_54 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r42 x_PM_LS_LHEN_X4%VSS_16 x_PM_LS_LHEN_X4%VSS_17 1.29647
R_x_PM_LS_LHEN_X4%VSS_r43 x_PM_LS_LHEN_X4%VSS_13 VSS 11.0647
R_x_PM_LS_LHEN_X4%VSS_r44 x_PM_LS_LHEN_X4%VSS_12 N_VSS_M7_b 0.140282
R_x_PM_LS_LHEN_X4%VSS_r45 x_PM_LS_LHEN_X4%VSS_52 x_PM_LS_LHEN_X4%VSS_12 7.68941
C_x_PM_LS_LHEN_X4%A_c0 x_PM_LS_LHEN_X4%A_21 VSS 0.0115399f
C_x_PM_LS_LHEN_X4%A_c1 x_PM_LS_LHEN_X4%A_14 VSS 0.08025f
C_x_PM_LS_LHEN_X4%A_c2 x_PM_LS_LHEN_X4%A_13 VSS 0.00484677f
C_x_PM_LS_LHEN_X4%A_c3 A VSS 0.0221181f
C_x_PM_LS_LHEN_X4%A_c4 N_A_M0_g VSS 0.0395466f
C_x_PM_LS_LHEN_X4%A_c5 N_A_M7_g VSS 0.0431614f
R_x_PM_LS_LHEN_X4%A_r6 x_PM_LS_LHEN_X4%A_16 x_PM_LS_LHEN_X4%A_21 3.38
R_x_PM_LS_LHEN_X4%A_r7 x_PM_LS_LHEN_X4%A_18 x_PM_LS_LHEN_X4%A_16 1.3
R_x_PM_LS_LHEN_X4%A_r8 x_PM_LS_LHEN_X4%A_14 x_PM_LS_LHEN_X4%A_16 25.0012
R_x_PM_LS_LHEN_X4%A_r9 x_PM_LS_LHEN_X4%A_13 x_PM_LS_LHEN_X4%A_14 0.936429
R_x_PM_LS_LHEN_X4%A_r10 x_PM_LS_LHEN_X4%A_9 x_PM_LS_LHEN_X4%A_13 0.212317
R_x_PM_LS_LHEN_X4%A_r11 x_PM_LS_LHEN_X4%A_9 A 0.488571
R_x_PM_LS_LHEN_X4%A_r12 x_PM_LS_LHEN_X4%A_5 x_PM_LS_LHEN_X4%A_21 1.95
R_x_PM_LS_LHEN_X4%A_r13 x_PM_LS_LHEN_X4%A_5 N_A_M0_g 35.1
R_x_PM_LS_LHEN_X4%A_r14 x_PM_LS_LHEN_X4%A_1 x_PM_LS_LHEN_X4%A_18 1.95
R_x_PM_LS_LHEN_X4%A_r15 x_PM_LS_LHEN_X4%A_1 N_A_M7_g 39.78
C_x_PM_LS_LHEN_X4%4_c0 x_PM_LS_LHEN_X4%4_38 VSS 0.0568294f
C_x_PM_LS_LHEN_X4%4_c1 x_PM_LS_LHEN_X4%4_34 VSS 0.0283584f
C_x_PM_LS_LHEN_X4%4_c2 x_PM_LS_LHEN_X4%4_33 VSS 0.0640268f
C_x_PM_LS_LHEN_X4%4_c3 x_PM_LS_LHEN_X4%4_32 VSS 0.0175053f
C_x_PM_LS_LHEN_X4%4_c4 x_PM_LS_LHEN_X4%4_31 VSS 0.0602627f
C_x_PM_LS_LHEN_X4%4_c5 N_4_M0_s VSS 0.0282286f
C_x_PM_LS_LHEN_X4%4_c6 N_4_M7_s VSS 0.0341836f
C_x_PM_LS_LHEN_X4%4_c7 x_PM_LS_LHEN_X4%4_17 VSS 0.0240064f
C_x_PM_LS_LHEN_X4%4_c8 N_4_M11_g VSS 0.0507166f
C_x_PM_LS_LHEN_X4%4_c9 x_PM_LS_LHEN_X4%4_11 VSS 0.0692516f
C_x_PM_LS_LHEN_X4%4_c10 x_PM_LS_LHEN_X4%4_10 VSS 0.0103126f
C_x_PM_LS_LHEN_X4%4_c11 x_PM_LS_LHEN_X4%4_9 VSS 0.0242023f
C_x_PM_LS_LHEN_X4%4_c12 N_4_M1_g VSS 0.0326218f
C_x_PM_LS_LHEN_X4%4_c13 N_4_M8_g VSS 0.0364027f
R_x_PM_LS_LHEN_X4%4_r14 x_PM_LS_LHEN_X4%4_42 x_PM_LS_LHEN_X4%4_43 4.68
R_x_PM_LS_LHEN_X4%4_r15 x_PM_LS_LHEN_X4%4_40 x_PM_LS_LHEN_X4%4_42 0.78
R_x_PM_LS_LHEN_X4%4_r16 x_PM_LS_LHEN_X4%4_38 x_PM_LS_LHEN_X4%4_40 25.0012
R_x_PM_LS_LHEN_X4%4_r17 x_PM_LS_LHEN_X4%4_36 x_PM_LS_LHEN_X4%4_38 0.556429
R_x_PM_LS_LHEN_X4%4_r18 x_PM_LS_LHEN_X4%4_35 x_PM_LS_LHEN_X4%4_38 0.529286
R_x_PM_LS_LHEN_X4%4_r19 x_PM_LS_LHEN_X4%4_33 x_PM_LS_LHEN_X4%4_36 0.212317
R_x_PM_LS_LHEN_X4%4_r20 x_PM_LS_LHEN_X4%4_33 x_PM_LS_LHEN_X4%4_34 0.868571
R_x_PM_LS_LHEN_X4%4_r21 x_PM_LS_LHEN_X4%4_31 x_PM_LS_LHEN_X4%4_35 0.212317
R_x_PM_LS_LHEN_X4%4_r22 x_PM_LS_LHEN_X4%4_31 x_PM_LS_LHEN_X4%4_32 1.11286
R_x_PM_LS_LHEN_X4%4_r23 x_PM_LS_LHEN_X4%4_27 x_PM_LS_LHEN_X4%4_34 0.212317
R_x_PM_LS_LHEN_X4%4_r24 x_PM_LS_LHEN_X4%4_27 N_4_M0_s 0.475
R_x_PM_LS_LHEN_X4%4_r25 x_PM_LS_LHEN_X4%4_23 x_PM_LS_LHEN_X4%4_32 0.212317
R_x_PM_LS_LHEN_X4%4_r26 x_PM_LS_LHEN_X4%4_23 N_4_M7_s 0.637857
R_x_PM_LS_LHEN_X4%4_r27 x_PM_LS_LHEN_X4%4_17 x_PM_LS_LHEN_X4%4_19 11.96
R_x_PM_LS_LHEN_X4%4_r28 x_PM_LS_LHEN_X4%4_13 N_4_M11_g 47.58
R_x_PM_LS_LHEN_X4%4_r29 x_PM_LS_LHEN_X4%4_12 x_PM_LS_LHEN_X4%4_19 1.95
R_x_PM_LS_LHEN_X4%4_r30 x_PM_LS_LHEN_X4%4_11 x_PM_LS_LHEN_X4%4_13 4.58872
R_x_PM_LS_LHEN_X4%4_r31 x_PM_LS_LHEN_X4%4_11 x_PM_LS_LHEN_X4%4_12 54.6
R_x_PM_LS_LHEN_X4%4_r32 x_PM_LS_LHEN_X4%4_10 x_PM_LS_LHEN_X4%4_43 2.6
R_x_PM_LS_LHEN_X4%4_r33 x_PM_LS_LHEN_X4%4_9 x_PM_LS_LHEN_X4%4_17 1.95
R_x_PM_LS_LHEN_X4%4_r34 x_PM_LS_LHEN_X4%4_9 x_PM_LS_LHEN_X4%4_10 20.28
R_x_PM_LS_LHEN_X4%4_r35 x_PM_LS_LHEN_X4%4_5 x_PM_LS_LHEN_X4%4_43 1.95
R_x_PM_LS_LHEN_X4%4_r36 x_PM_LS_LHEN_X4%4_5 N_4_M1_g 35.1
R_x_PM_LS_LHEN_X4%4_r37 x_PM_LS_LHEN_X4%4_1 x_PM_LS_LHEN_X4%4_42 1.95
R_x_PM_LS_LHEN_X4%4_r38 x_PM_LS_LHEN_X4%4_1 N_4_M8_g 39.78
C_x_PM_LS_LHEN_X4%VDDL_c0 VDDL VSS 0.0679693f
C_x_PM_LS_LHEN_X4%VDDL_c1 x_PM_LS_LHEN_X4%VDDL_6 VSS 0.0646917f
R_x_PM_LS_LHEN_X4%VDDL_r2 x_PM_LS_LHEN_X4%VDDL_11 VDDL 0.16625
R_x_PM_LS_LHEN_X4%VDDL_r3 N_VDDL_M0_b x_PM_LS_LHEN_X4%VDDL_11 0.0095
R_x_PM_LS_LHEN_X4%VDDL_r4 x_PM_LS_LHEN_X4%VDDL_6 x_PM_LS_LHEN_X4%VDDL_11 0.095
R_x_PM_LS_LHEN_X4%VDDL_r5 N_VDDL_M0_d x_PM_LS_LHEN_X4%VDDL_6 0.347287
C_x_PM_LS_LHEN_X4%6_c0 x_PM_LS_LHEN_X4%6_28 VSS 0.0148235f
C_x_PM_LS_LHEN_X4%6_c1 x_PM_LS_LHEN_X4%6_25 VSS 0.0180551f
C_x_PM_LS_LHEN_X4%6_c2 x_PM_LS_LHEN_X4%6_23 VSS 0.0459741f
C_x_PM_LS_LHEN_X4%6_c3 x_PM_LS_LHEN_X4%6_17 VSS 0.0210126f
C_x_PM_LS_LHEN_X4%6_c4 x_PM_LS_LHEN_X4%6_13 VSS 0.0479047f
C_x_PM_LS_LHEN_X4%6_c5 N_6_M1_d VSS 0.0480368f
C_x_PM_LS_LHEN_X4%6_c6 x_PM_LS_LHEN_X4%6_8 VSS 0.0495792f
C_x_PM_LS_LHEN_X4%6_c7 N_6_M10_g VSS 0.0281997f
R_x_PM_LS_LHEN_X4%6_r8 x_PM_LS_LHEN_X4%6_26 x_PM_LS_LHEN_X4%6_28 4.42
R_x_PM_LS_LHEN_X4%6_r9 N_6_M8_d x_PM_LS_LHEN_X4%6_23 0.230714
R_x_PM_LS_LHEN_X4%6_r10 x_PM_LS_LHEN_X4%6_17 x_PM_LS_LHEN_X4%6_26 25.0012
R_x_PM_LS_LHEN_X4%6_r11 x_PM_LS_LHEN_X4%6_15 x_PM_LS_LHEN_X4%6_17 0.285
R_x_PM_LS_LHEN_X4%6_r12 x_PM_LS_LHEN_X4%6_14 x_PM_LS_LHEN_X4%6_25 0.0418175
R_x_PM_LS_LHEN_X4%6_r13 x_PM_LS_LHEN_X4%6_13 x_PM_LS_LHEN_X4%6_15 0.212317
R_x_PM_LS_LHEN_X4%6_r14 x_PM_LS_LHEN_X4%6_13 x_PM_LS_LHEN_X4%6_14 1.62857
R_x_PM_LS_LHEN_X4%6_r15 x_PM_LS_LHEN_X4%6_9 x_PM_LS_LHEN_X4%6_25 0.160909
R_x_PM_LS_LHEN_X4%6_r16 x_PM_LS_LHEN_X4%6_9 N_6_M1_d 1.045
R_x_PM_LS_LHEN_X4%6_r17 x_PM_LS_LHEN_X4%6_8 x_PM_LS_LHEN_X4%6_25 0.160909
R_x_PM_LS_LHEN_X4%6_r18 x_PM_LS_LHEN_X4%6_7 x_PM_LS_LHEN_X4%6_23 0.095
R_x_PM_LS_LHEN_X4%6_r19 x_PM_LS_LHEN_X4%6_7 x_PM_LS_LHEN_X4%6_8 1.38429
R_x_PM_LS_LHEN_X4%6_r20 x_PM_LS_LHEN_X4%6_1 x_PM_LS_LHEN_X4%6_28 1.95
R_x_PM_LS_LHEN_X4%6_r21 x_PM_LS_LHEN_X4%6_1 N_6_M10_g 21.06
C_x_PM_LS_LHEN_X4%7_c0 x_PM_LS_LHEN_X4%7_21 VSS 0.0222597f
C_x_PM_LS_LHEN_X4%7_c1 x_PM_LS_LHEN_X4%7_18 VSS 0.00760338f
C_x_PM_LS_LHEN_X4%7_c2 x_PM_LS_LHEN_X4%7_17 VSS 0.0402919f
C_x_PM_LS_LHEN_X4%7_c3 N_7_M2_s VSS 0.0696407f
C_x_PM_LS_LHEN_X4%7_c4 N_7_M10_d VSS 0.107281f
C_x_PM_LS_LHEN_X4%7_c5 N_7_M3_g VSS 0.0536298f
R_x_PM_LS_LHEN_X4%7_r6 x_PM_LS_LHEN_X4%7_17 x_PM_LS_LHEN_X4%7_18 0.0341169
R_x_PM_LS_LHEN_X4%7_r7 x_PM_LS_LHEN_X4%7_16 x_PM_LS_LHEN_X4%7_21 6.65294
R_x_PM_LS_LHEN_X4%7_r8 x_PM_LS_LHEN_X4%7_15 x_PM_LS_LHEN_X4%7_17 0.533203
R_x_PM_LS_LHEN_X4%7_r9 x_PM_LS_LHEN_X4%7_15 x_PM_LS_LHEN_X4%7_16 25.0012
R_x_PM_LS_LHEN_X4%7_r10 x_PM_LS_LHEN_X4%7_11 x_PM_LS_LHEN_X4%7_18 0.170353
R_x_PM_LS_LHEN_X4%7_r11 x_PM_LS_LHEN_X4%7_7 x_PM_LS_LHEN_X4%7_18 0.170353
R_x_PM_LS_LHEN_X4%7_r12 x_PM_LS_LHEN_X4%7_7 N_7_M2_s 1.94071
R_x_PM_LS_LHEN_X4%7_r13 x_PM_LS_LHEN_X4%7_11 N_7_M10_d 2.59214
R_x_PM_LS_LHEN_X4%7_r14 x_PM_LS_LHEN_X4%7_1 x_PM_LS_LHEN_X4%7_21 1.95
R_x_PM_LS_LHEN_X4%7_r15 x_PM_LS_LHEN_X4%7_1 N_7_M3_g 55.38
C_x_PM_LS_LHEN_X4%8_c0 x_PM_LS_LHEN_X4%8_47 VSS 0.0100619f
C_x_PM_LS_LHEN_X4%8_c1 x_PM_LS_LHEN_X4%8_40 VSS 0.00342345f
C_x_PM_LS_LHEN_X4%8_c2 x_PM_LS_LHEN_X4%8_37 VSS 0.109784f
C_x_PM_LS_LHEN_X4%8_c3 x_PM_LS_LHEN_X4%8_31 VSS 0.0182707f
C_x_PM_LS_LHEN_X4%8_c4 x_PM_LS_LHEN_X4%8_29 VSS 0.0483681f
C_x_PM_LS_LHEN_X4%8_c5 N_8_M3_d VSS 0.0400068f
C_x_PM_LS_LHEN_X4%8_c6 x_PM_LS_LHEN_X4%8_24 VSS 0.0436236f
C_x_PM_LS_LHEN_X4%8_c7 x_PM_LS_LHEN_X4%8_22 VSS 0.0187278f
C_x_PM_LS_LHEN_X4%8_c8 x_PM_LS_LHEN_X4%8_21 VSS 0.0110674f
C_x_PM_LS_LHEN_X4%8_c9 x_PM_LS_LHEN_X4%8_19 VSS 0.021181f
C_x_PM_LS_LHEN_X4%8_c10 N_8_M11_s VSS 0.0539142f
C_x_PM_LS_LHEN_X4%8_c11 N_8_M5_g VSS 0.0758528f
C_x_PM_LS_LHEN_X4%8_c12 N_8_M14_g VSS 0.0375578f
C_x_PM_LS_LHEN_X4%8_c13 N_8_M2_g VSS 0.0313493f
R_x_PM_LS_LHEN_X4%8_r14 x_PM_LS_LHEN_X4%8_45 x_PM_LS_LHEN_X4%8_47 2.86
R_x_PM_LS_LHEN_X4%8_r15 x_PM_LS_LHEN_X4%8_37 x_PM_LS_LHEN_X4%8_45 25.0012
R_x_PM_LS_LHEN_X4%8_r16 x_PM_LS_LHEN_X4%8_35 x_PM_LS_LHEN_X4%8_37 3.24357
R_x_PM_LS_LHEN_X4%8_r17 x_PM_LS_LHEN_X4%8_41 x_PM_LS_LHEN_X4%8_31 3.44118
R_x_PM_LS_LHEN_X4%8_r18 x_PM_LS_LHEN_X4%8_29 x_PM_LS_LHEN_X4%8_31 25.0012
R_x_PM_LS_LHEN_X4%8_r19 x_PM_LS_LHEN_X4%8_29 x_PM_LS_LHEN_X4%8_33 0.156471
R_x_PM_LS_LHEN_X4%8_r20 x_PM_LS_LHEN_X4%8_25 x_PM_LS_LHEN_X4%8_40 0.188527
R_x_PM_LS_LHEN_X4%8_r21 x_PM_LS_LHEN_X4%8_25 N_8_M3_d 0.665
R_x_PM_LS_LHEN_X4%8_r22 x_PM_LS_LHEN_X4%8_24 x_PM_LS_LHEN_X4%8_40 0.188527
R_x_PM_LS_LHEN_X4%8_r23 x_PM_LS_LHEN_X4%8_23 x_PM_LS_LHEN_X4%8_35 0.095
R_x_PM_LS_LHEN_X4%8_r24 x_PM_LS_LHEN_X4%8_23 x_PM_LS_LHEN_X4%8_24 2.30714
R_x_PM_LS_LHEN_X4%8_r25 x_PM_LS_LHEN_X4%8_21 x_PM_LS_LHEN_X4%8_35 0.19
R_x_PM_LS_LHEN_X4%8_r26 x_PM_LS_LHEN_X4%8_21 x_PM_LS_LHEN_X4%8_22 0.624286
R_x_PM_LS_LHEN_X4%8_r27 x_PM_LS_LHEN_X4%8_20 x_PM_LS_LHEN_X4%8_33 0.095
R_x_PM_LS_LHEN_X4%8_r28 x_PM_LS_LHEN_X4%8_19 x_PM_LS_LHEN_X4%8_40 0.0203602
R_x_PM_LS_LHEN_X4%8_r29 x_PM_LS_LHEN_X4%8_19 x_PM_LS_LHEN_X4%8_20 0.715294
R_x_PM_LS_LHEN_X4%8_r30 x_PM_LS_LHEN_X4%8_15 x_PM_LS_LHEN_X4%8_22 0.212317
R_x_PM_LS_LHEN_X4%8_r31 x_PM_LS_LHEN_X4%8_15 N_8_M11_s 1.09929
R_x_PM_LS_LHEN_X4%8_r32 x_PM_LS_LHEN_X4%8_9 x_PM_LS_LHEN_X4%8_47 1.95
R_x_PM_LS_LHEN_X4%8_r33 x_PM_LS_LHEN_X4%8_9 N_8_M5_g 98.28
R_x_PM_LS_LHEN_X4%8_r34 x_PM_LS_LHEN_X4%8_5 x_PM_LS_LHEN_X4%8_47 1.95
R_x_PM_LS_LHEN_X4%8_r35 x_PM_LS_LHEN_X4%8_5 N_8_M14_g 39
R_x_PM_LS_LHEN_X4%8_r36 x_PM_LS_LHEN_X4%8_1 x_PM_LS_LHEN_X4%8_41 1.95
R_x_PM_LS_LHEN_X4%8_r37 x_PM_LS_LHEN_X4%8_1 N_8_M2_g 25.74
C_x_PM_LS_LHEN_X4%ISOLN_c0 ISOLN VSS 0.024821f
C_x_PM_LS_LHEN_X4%ISOLN_c1 x_PM_LS_LHEN_X4%ISOLN_21 VSS 0.00441236f
C_x_PM_LS_LHEN_X4%ISOLN_c2 x_PM_LS_LHEN_X4%ISOLN_20 VSS 0.0235163f
C_x_PM_LS_LHEN_X4%ISOLN_c3 x_PM_LS_LHEN_X4%ISOLN_19 VSS 0.00807449f
C_x_PM_LS_LHEN_X4%ISOLN_c4 N_ISOLN_M4_g VSS 0.0525128f
C_x_PM_LS_LHEN_X4%ISOLN_c5 N_ISOLN_M13_g VSS 0.0685409f
C_x_PM_LS_LHEN_X4%ISOLN_c6 N_ISOLN_M12_g VSS 0.0640436f
C_x_PM_LS_LHEN_X4%ISOLN_c7 x_PM_LS_LHEN_X4%ISOLN_6 VSS 0.00601436f
C_x_PM_LS_LHEN_X4%ISOLN_c8 x_PM_LS_LHEN_X4%ISOLN_5 VSS 0.0905403f
C_x_PM_LS_LHEN_X4%ISOLN_c9 N_ISOLN_M9_g VSS 0.0326862f
R_x_PM_LS_LHEN_X4%ISOLN_r10 x_PM_LS_LHEN_X4%ISOLN_22 x_PM_LS_LHEN_X4%ISOLN_24 25.0012
R_x_PM_LS_LHEN_X4%ISOLN_r11 x_PM_LS_LHEN_X4%ISOLN_22 ISOLN 0.169643
R_x_PM_LS_LHEN_X4%ISOLN_r12 x_PM_LS_LHEN_X4%ISOLN_20 x_PM_LS_LHEN_X4%ISOLN_24 13.78
R_x_PM_LS_LHEN_X4%ISOLN_r13 x_PM_LS_LHEN_X4%ISOLN_20 x_PM_LS_LHEN_X4%ISOLN_21 0.043368
R_x_PM_LS_LHEN_X4%ISOLN_r14 x_PM_LS_LHEN_X4%ISOLN_19 x_PM_LS_LHEN_X4%ISOLN_24 16.38
R_x_PM_LS_LHEN_X4%ISOLN_r15 x_PM_LS_LHEN_X4%ISOLN_15 x_PM_LS_LHEN_X4%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X4%ISOLN_r16 x_PM_LS_LHEN_X4%ISOLN_15 N_ISOLN_M4_g 62.4
R_x_PM_LS_LHEN_X4%ISOLN_r17 x_PM_LS_LHEN_X4%ISOLN_11 x_PM_LS_LHEN_X4%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X4%ISOLN_r18 x_PM_LS_LHEN_X4%ISOLN_11 N_ISOLN_M13_g 74.88
R_x_PM_LS_LHEN_X4%ISOLN_r19 x_PM_LS_LHEN_X4%ISOLN_8 x_PM_LS_LHEN_X4%ISOLN_19 4.58872
R_x_PM_LS_LHEN_X4%ISOLN_r20 x_PM_LS_LHEN_X4%ISOLN_8 N_ISOLN_M12_g 65.52
R_x_PM_LS_LHEN_X4%ISOLN_r21 x_PM_LS_LHEN_X4%ISOLN_7 N_ISOLN_M12_g 26.52
R_x_PM_LS_LHEN_X4%ISOLN_r22 x_PM_LS_LHEN_X4%ISOLN_5 x_PM_LS_LHEN_X4%ISOLN_7 4.35808
R_x_PM_LS_LHEN_X4%ISOLN_r23 x_PM_LS_LHEN_X4%ISOLN_5 x_PM_LS_LHEN_X4%ISOLN_6 104.52
R_x_PM_LS_LHEN_X4%ISOLN_r24 x_PM_LS_LHEN_X4%ISOLN_1 x_PM_LS_LHEN_X4%ISOLN_6 4.35808
R_x_PM_LS_LHEN_X4%ISOLN_r25 x_PM_LS_LHEN_X4%ISOLN_1 N_ISOLN_M9_g 26.52
C_x_PM_LS_LHEN_X4%10_c0 x_PM_LS_LHEN_X4%10_30 VSS 0.0127458f
C_x_PM_LS_LHEN_X4%10_c1 x_PM_LS_LHEN_X4%10_26 VSS 0.122444f
C_x_PM_LS_LHEN_X4%10_c2 x_PM_LS_LHEN_X4%10_22 VSS 0.00626165f
C_x_PM_LS_LHEN_X4%10_c3 x_PM_LS_LHEN_X4%10_21 VSS 0.0374523f
C_x_PM_LS_LHEN_X4%10_c4 N_10_M4_d VSS 0.0391572f
C_x_PM_LS_LHEN_X4%10_c5 x_PM_LS_LHEN_X4%10_16 VSS 0.0173686f
C_x_PM_LS_LHEN_X4%10_c6 x_PM_LS_LHEN_X4%10_15 VSS 0.0971351f
C_x_PM_LS_LHEN_X4%10_c7 N_10_M13_s VSS 0.0420865f
C_x_PM_LS_LHEN_X4%10_c8 N_10_M6_g VSS 0.0774471f
C_x_PM_LS_LHEN_X4%10_c9 N_10_M15_g VSS 0.0511262f
R_x_PM_LS_LHEN_X4%10_r10 x_PM_LS_LHEN_X4%10_28 x_PM_LS_LHEN_X4%10_30 4.42
R_x_PM_LS_LHEN_X4%10_r11 x_PM_LS_LHEN_X4%10_26 x_PM_LS_LHEN_X4%10_28 25.0012
R_x_PM_LS_LHEN_X4%10_r12 x_PM_LS_LHEN_X4%10_24 x_PM_LS_LHEN_X4%10_26 1.995
R_x_PM_LS_LHEN_X4%10_r13 x_PM_LS_LHEN_X4%10_23 x_PM_LS_LHEN_X4%10_26 0.990714
R_x_PM_LS_LHEN_X4%10_r14 x_PM_LS_LHEN_X4%10_21 x_PM_LS_LHEN_X4%10_24 0.212317
R_x_PM_LS_LHEN_X4%10_r15 x_PM_LS_LHEN_X4%10_21 x_PM_LS_LHEN_X4%10_22 0.922857
R_x_PM_LS_LHEN_X4%10_r16 x_PM_LS_LHEN_X4%10_17 x_PM_LS_LHEN_X4%10_22 0.212317
R_x_PM_LS_LHEN_X4%10_r17 x_PM_LS_LHEN_X4%10_17 N_10_M4_d 0.773571
R_x_PM_LS_LHEN_X4%10_r18 x_PM_LS_LHEN_X4%10_15 x_PM_LS_LHEN_X4%10_23 0.212317
R_x_PM_LS_LHEN_X4%10_r19 x_PM_LS_LHEN_X4%10_15 x_PM_LS_LHEN_X4%10_16 1.95429
R_x_PM_LS_LHEN_X4%10_r20 x_PM_LS_LHEN_X4%10_11 x_PM_LS_LHEN_X4%10_16 0.212317
R_x_PM_LS_LHEN_X4%10_r21 x_PM_LS_LHEN_X4%10_11 N_10_M13_s 0.556429
R_x_PM_LS_LHEN_X4%10_r22 x_PM_LS_LHEN_X4%10_5 x_PM_LS_LHEN_X4%10_30 1.95
R_x_PM_LS_LHEN_X4%10_r23 x_PM_LS_LHEN_X4%10_5 N_10_M6_g 54.6
R_x_PM_LS_LHEN_X4%10_r24 x_PM_LS_LHEN_X4%10_1 x_PM_LS_LHEN_X4%10_30 1.95
R_x_PM_LS_LHEN_X4%10_r25 x_PM_LS_LHEN_X4%10_1 N_10_M15_g 35.88
C_x_PM_LS_LHEN_X4%Z_c0 N_Z_M15_d VSS 0.179332f
R_x_PM_LS_LHEN_X4%Z_r1 Z N_Z_M6_d 2.755
R_x_PM_LS_LHEN_X4%Z_r2 N_Z_M15_d Z 1.235
.ENDS

********************************************************************************
*
* END
*
********************************************************************************
