*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2011, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *     NGLibraryCreator, v2010.08-HR32-SP3-2010-08-05 - build 1009061800      *
* *                                                                            *
* ******************************************************************************
*
*
* Running on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr).
* Local time is now Tue, 4 Jan 2011, 14:44:41.
* Main process id is 1680.
*
********************************************************************************
*                                                                              *
* Cellname:   LS_LHEN_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LHEN_X2 VDD VSS A VDDL ISOLN Z
*.PININFO VDD:P VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M9 N_VDDL_M0_d N_A_M0_g N_4_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M10 N_6_M1_d N_4_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M11 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M12 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M13 N_10_M4_d N_ISOLN_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M14 N_VDD_M5_d N_8_M5_g N_10_M4_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M15 N_Z_M6_d N_10_M6_g N_VDD_M5_d N_VDD_M2_b PMOS_VTL L=5e-08 W=2.7e-07
M_M0 N_VSS_M7_d N_A_M7_g N_4_M7_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M8_d N_4_M8_g N_VSS_M7_d N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M2 12 N_ISOLN_M9_g N_VSS_M9_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_7_M10_d N_6_M10_g 12 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M4 13 N_4_M11_g N_8_M11_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M5 N_VSS_M12_d N_ISOLN_M12_g 13 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M6 14 N_ISOLN_M13_g N_10_M13_s N_VSS_M7_b NMOS_VTL L=5e-08 W=1.3e-07
M_M7 N_VSS_M14_d N_8_M14_g 14 N_VSS_M7_b NMOS_VTL L=5e-08 W=1.3e-07
M_M8 N_Z_M15_d N_10_M15_g N_VSS_M14_d N_VSS_M7_b NMOS_VTL L=5e-08 W=1.8e-07
C_x_PM_LS_LHEN_X2%VDD_c0 x_PM_LS_LHEN_X2%VDD_49 VSS 0.0225764f
C_x_PM_LS_LHEN_X2%VDD_c1 x_PM_LS_LHEN_X2%VDD_46 VSS 0.00566898f
C_x_PM_LS_LHEN_X2%VDD_c2 x_PM_LS_LHEN_X2%VDD_45 VSS 0.00296767f
C_x_PM_LS_LHEN_X2%VDD_c3 x_PM_LS_LHEN_X2%VDD_44 VSS 0.00292673f
C_x_PM_LS_LHEN_X2%VDD_c4 x_PM_LS_LHEN_X2%VDD_43 VSS 0.0108319f
C_x_PM_LS_LHEN_X2%VDD_c5 x_PM_LS_LHEN_X2%VDD_42 VSS 0.2334f
C_x_PM_LS_LHEN_X2%VDD_c6 x_PM_LS_LHEN_X2%VDD_33 VSS 0.261448f
C_x_PM_LS_LHEN_X2%VDD_c7 x_PM_LS_LHEN_X2%VDD_30 VSS 0.0326315f
C_x_PM_LS_LHEN_X2%VDD_c8 x_PM_LS_LHEN_X2%VDD_27 VSS 0.0206865f
C_x_PM_LS_LHEN_X2%VDD_c9 N_VDD_M4_s VSS 0.028069f
C_x_PM_LS_LHEN_X2%VDD_c10 x_PM_LS_LHEN_X2%VDD_21 VSS 0.0394772f
C_x_PM_LS_LHEN_X2%VDD_c11 N_VDD_M2_d VSS 0.0291285f
C_x_PM_LS_LHEN_X2%VDD_c12 x_PM_LS_LHEN_X2%VDD_15 VSS 0.122964f
C_x_PM_LS_LHEN_X2%VDD_c13 x_PM_LS_LHEN_X2%VDD_14 VSS 0.0192462f
C_x_PM_LS_LHEN_X2%VDD_c14 x_PM_LS_LHEN_X2%VDD_10 VSS 0.706493f
R_x_PM_LS_LHEN_X2%VDD_r15 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_49 0.13879
R_x_PM_LS_LHEN_X2%VDD_r16 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_43 0.138595
R_x_PM_LS_LHEN_X2%VDD_r17 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_42 0.138985
R_x_PM_LS_LHEN_X2%VDD_r18 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_33 0.13879
R_x_PM_LS_LHEN_X2%VDD_r19 x_PM_LS_LHEN_X2%VDD_33 VDD 3.84471
R_x_PM_LS_LHEN_X2%VDD_r20 x_PM_LS_LHEN_X2%VDD_32 x_PM_LS_LHEN_X2%VDD_46 0.132285
R_x_PM_LS_LHEN_X2%VDD_r21 x_PM_LS_LHEN_X2%VDD_49 x_PM_LS_LHEN_X2%VDD_32 0.57
R_x_PM_LS_LHEN_X2%VDD_r22 x_PM_LS_LHEN_X2%VDD_30 x_PM_LS_LHEN_X2%VDD_46 0.0680382
R_x_PM_LS_LHEN_X2%VDD_r23 N_VDD_M5_d x_PM_LS_LHEN_X2%VDD_30 0.375435
R_x_PM_LS_LHEN_X2%VDD_r24 x_PM_LS_LHEN_X2%VDD_28 x_PM_LS_LHEN_X2%VDD_45 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r25 x_PM_LS_LHEN_X2%VDD_27 x_PM_LS_LHEN_X2%VDD_46 0.132285
R_x_PM_LS_LHEN_X2%VDD_r26 x_PM_LS_LHEN_X2%VDD_27 x_PM_LS_LHEN_X2%VDD_28 0.625882
R_x_PM_LS_LHEN_X2%VDD_r27 x_PM_LS_LHEN_X2%VDD_23 x_PM_LS_LHEN_X2%VDD_45 0.145286
R_x_PM_LS_LHEN_X2%VDD_r28 x_PM_LS_LHEN_X2%VDD_23 N_VDD_M4_s 1.07214
R_x_PM_LS_LHEN_X2%VDD_r29 x_PM_LS_LHEN_X2%VDD_22 x_PM_LS_LHEN_X2%VDD_44 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r30 x_PM_LS_LHEN_X2%VDD_21 x_PM_LS_LHEN_X2%VDD_45 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r31 x_PM_LS_LHEN_X2%VDD_21 x_PM_LS_LHEN_X2%VDD_22 1.02824
R_x_PM_LS_LHEN_X2%VDD_r32 x_PM_LS_LHEN_X2%VDD_17 x_PM_LS_LHEN_X2%VDD_44 0.145286
R_x_PM_LS_LHEN_X2%VDD_r33 x_PM_LS_LHEN_X2%VDD_17 N_VDD_M2_d 0.502143
R_x_PM_LS_LHEN_X2%VDD_r34 x_PM_LS_LHEN_X2%VDD_15 x_PM_LS_LHEN_X2%VDD_44 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r35 x_PM_LS_LHEN_X2%VDD_15 x_PM_LS_LHEN_X2%VDD_43 3.30824
R_x_PM_LS_LHEN_X2%VDD_r36 x_PM_LS_LHEN_X2%VDD_14 N_VDD_M2_b 0.140282
R_x_PM_LS_LHEN_X2%VDD_r37 x_PM_LS_LHEN_X2%VDD_42 x_PM_LS_LHEN_X2%VDD_14 7.68941
R_x_PM_LS_LHEN_X2%VDD_r38 x_PM_LS_LHEN_X2%VDD_10 VDD 11.0647
C_x_PM_LS_LHEN_X2%VSS_c0 x_PM_LS_LHEN_X2%VSS_57 VSS 0.00562691f
C_x_PM_LS_LHEN_X2%VSS_c1 x_PM_LS_LHEN_X2%VSS_56 VSS 0.00281563f
C_x_PM_LS_LHEN_X2%VSS_c2 x_PM_LS_LHEN_X2%VSS_55 VSS 0.00281385f
C_x_PM_LS_LHEN_X2%VSS_c3 x_PM_LS_LHEN_X2%VSS_54 VSS 0.00293741f
C_x_PM_LS_LHEN_X2%VSS_c4 x_PM_LS_LHEN_X2%VSS_52 VSS 0.2334f
C_x_PM_LS_LHEN_X2%VSS_c5 N_VSS_M7_b VSS 0.261559f
C_x_PM_LS_LHEN_X2%VSS_c6 x_PM_LS_LHEN_X2%VSS_42 VSS 0.0220233f
C_x_PM_LS_LHEN_X2%VSS_c7 N_VSS_M14_d VSS 0.0252241f
C_x_PM_LS_LHEN_X2%VSS_c8 x_PM_LS_LHEN_X2%VSS_36 VSS 0.0382058f
C_x_PM_LS_LHEN_X2%VSS_c9 N_VSS_M12_d VSS 0.0382663f
C_x_PM_LS_LHEN_X2%VSS_c10 x_PM_LS_LHEN_X2%VSS_28 VSS 0.0908707f
C_x_PM_LS_LHEN_X2%VSS_c11 N_VSS_M9_s VSS 0.0459145f
C_x_PM_LS_LHEN_X2%VSS_c12 x_PM_LS_LHEN_X2%VSS_22 VSS 0.0357401f
C_x_PM_LS_LHEN_X2%VSS_c13 N_VSS_M7_d VSS 0.0409801f
C_x_PM_LS_LHEN_X2%VSS_c14 x_PM_LS_LHEN_X2%VSS_17 VSS 0.0106021f
C_x_PM_LS_LHEN_X2%VSS_c15 x_PM_LS_LHEN_X2%VSS_16 VSS 0.0548707f
C_x_PM_LS_LHEN_X2%VSS_c16 x_PM_LS_LHEN_X2%VSS_13 VSS 0.706493f
C_x_PM_LS_LHEN_X2%VSS_c17 x_PM_LS_LHEN_X2%VSS_12 VSS 0.0192462f
R_x_PM_LS_LHEN_X2%VSS_r18 N_VSS_M7_b x_PM_LS_LHEN_X2%VSS_52 0.138985
R_x_PM_LS_LHEN_X2%VSS_r19 x_PM_LS_LHEN_X2%VSS_43 x_PM_LS_LHEN_X2%VSS_57 0.132285
R_x_PM_LS_LHEN_X2%VSS_r20 N_VSS_M7_b x_PM_LS_LHEN_X2%VSS_42 0.13879
R_x_PM_LS_LHEN_X2%VSS_r21 x_PM_LS_LHEN_X2%VSS_42 x_PM_LS_LHEN_X2%VSS_43 0.57
R_x_PM_LS_LHEN_X2%VSS_r22 x_PM_LS_LHEN_X2%VSS_38 x_PM_LS_LHEN_X2%VSS_57 0.0680382
R_x_PM_LS_LHEN_X2%VSS_r23 x_PM_LS_LHEN_X2%VSS_38 N_VSS_M14_d 0.302593
R_x_PM_LS_LHEN_X2%VSS_r24 x_PM_LS_LHEN_X2%VSS_37 x_PM_LS_LHEN_X2%VSS_56 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r25 x_PM_LS_LHEN_X2%VSS_36 x_PM_LS_LHEN_X2%VSS_57 0.132285
R_x_PM_LS_LHEN_X2%VSS_r26 x_PM_LS_LHEN_X2%VSS_36 x_PM_LS_LHEN_X2%VSS_37 0.972353
R_x_PM_LS_LHEN_X2%VSS_r27 x_PM_LS_LHEN_X2%VSS_32 x_PM_LS_LHEN_X2%VSS_56 0.145286
R_x_PM_LS_LHEN_X2%VSS_r28 x_PM_LS_LHEN_X2%VSS_32 N_VSS_M12_d 1.01786
R_x_PM_LS_LHEN_X2%VSS_r29 x_PM_LS_LHEN_X2%VSS_29 x_PM_LS_LHEN_X2%VSS_55 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r30 x_PM_LS_LHEN_X2%VSS_29 VSS 0.782353
R_x_PM_LS_LHEN_X2%VSS_r31 x_PM_LS_LHEN_X2%VSS_28 x_PM_LS_LHEN_X2%VSS_56 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r32 x_PM_LS_LHEN_X2%VSS_28 VSS 1.07294
R_x_PM_LS_LHEN_X2%VSS_r33 x_PM_LS_LHEN_X2%VSS_24 x_PM_LS_LHEN_X2%VSS_55 0.145286
R_x_PM_LS_LHEN_X2%VSS_r34 x_PM_LS_LHEN_X2%VSS_24 N_VSS_M9_s 0.990714
R_x_PM_LS_LHEN_X2%VSS_r35 x_PM_LS_LHEN_X2%VSS_23 x_PM_LS_LHEN_X2%VSS_54 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r36 x_PM_LS_LHEN_X2%VSS_22 x_PM_LS_LHEN_X2%VSS_55 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r37 x_PM_LS_LHEN_X2%VSS_22 x_PM_LS_LHEN_X2%VSS_23 0.681765
R_x_PM_LS_LHEN_X2%VSS_r38 x_PM_LS_LHEN_X2%VSS_18 x_PM_LS_LHEN_X2%VSS_54 0.145286
R_x_PM_LS_LHEN_X2%VSS_r39 x_PM_LS_LHEN_X2%VSS_18 N_VSS_M7_d 0.637857
R_x_PM_LS_LHEN_X2%VSS_r40 N_VSS_M7_b x_PM_LS_LHEN_X2%VSS_17 0.138595
R_x_PM_LS_LHEN_X2%VSS_r41 x_PM_LS_LHEN_X2%VSS_16 x_PM_LS_LHEN_X2%VSS_54 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r42 x_PM_LS_LHEN_X2%VSS_16 x_PM_LS_LHEN_X2%VSS_17 1.29647
R_x_PM_LS_LHEN_X2%VSS_r43 x_PM_LS_LHEN_X2%VSS_13 VSS 11.0647
R_x_PM_LS_LHEN_X2%VSS_r44 x_PM_LS_LHEN_X2%VSS_12 N_VSS_M7_b 0.140282
R_x_PM_LS_LHEN_X2%VSS_r45 x_PM_LS_LHEN_X2%VSS_52 x_PM_LS_LHEN_X2%VSS_12 7.68941
C_x_PM_LS_LHEN_X2%A_c0 x_PM_LS_LHEN_X2%A_21 VSS 0.0117047f
C_x_PM_LS_LHEN_X2%A_c1 x_PM_LS_LHEN_X2%A_14 VSS 0.0807116f
C_x_PM_LS_LHEN_X2%A_c2 x_PM_LS_LHEN_X2%A_13 VSS 0.00484899f
C_x_PM_LS_LHEN_X2%A_c3 A VSS 0.0221116f
C_x_PM_LS_LHEN_X2%A_c4 N_A_M0_g VSS 0.0377071f
C_x_PM_LS_LHEN_X2%A_c5 N_A_M7_g VSS 0.0431427f
R_x_PM_LS_LHEN_X2%A_r6 x_PM_LS_LHEN_X2%A_16 x_PM_LS_LHEN_X2%A_21 2.86
R_x_PM_LS_LHEN_X2%A_r7 x_PM_LS_LHEN_X2%A_18 x_PM_LS_LHEN_X2%A_16 2.34
R_x_PM_LS_LHEN_X2%A_r8 x_PM_LS_LHEN_X2%A_14 x_PM_LS_LHEN_X2%A_16 25.0012
R_x_PM_LS_LHEN_X2%A_r9 x_PM_LS_LHEN_X2%A_13 x_PM_LS_LHEN_X2%A_14 0.963571
R_x_PM_LS_LHEN_X2%A_r10 x_PM_LS_LHEN_X2%A_9 x_PM_LS_LHEN_X2%A_13 0.212317
R_x_PM_LS_LHEN_X2%A_r11 x_PM_LS_LHEN_X2%A_9 A 0.488571
R_x_PM_LS_LHEN_X2%A_r12 x_PM_LS_LHEN_X2%A_5 x_PM_LS_LHEN_X2%A_21 1.95
R_x_PM_LS_LHEN_X2%A_r13 x_PM_LS_LHEN_X2%A_5 N_A_M0_g 31.98
R_x_PM_LS_LHEN_X2%A_r14 x_PM_LS_LHEN_X2%A_1 x_PM_LS_LHEN_X2%A_18 1.95
R_x_PM_LS_LHEN_X2%A_r15 x_PM_LS_LHEN_X2%A_1 N_A_M7_g 39.78
C_x_PM_LS_LHEN_X2%4_c0 x_PM_LS_LHEN_X2%4_36 VSS 0.0597866f
C_x_PM_LS_LHEN_X2%4_c1 x_PM_LS_LHEN_X2%4_32 VSS 0.0279334f
C_x_PM_LS_LHEN_X2%4_c2 x_PM_LS_LHEN_X2%4_31 VSS 0.0658776f
C_x_PM_LS_LHEN_X2%4_c3 x_PM_LS_LHEN_X2%4_30 VSS 0.0175113f
C_x_PM_LS_LHEN_X2%4_c4 x_PM_LS_LHEN_X2%4_29 VSS 0.0645231f
C_x_PM_LS_LHEN_X2%4_c5 N_4_M0_s VSS 0.0208149f
C_x_PM_LS_LHEN_X2%4_c6 N_4_M7_s VSS 0.0337191f
C_x_PM_LS_LHEN_X2%4_c7 N_4_M11_g VSS 0.053781f
C_x_PM_LS_LHEN_X2%4_c8 x_PM_LS_LHEN_X2%4_14 VSS 0.00856457f
C_x_PM_LS_LHEN_X2%4_c9 x_PM_LS_LHEN_X2%4_13 VSS 0.0716788f
C_x_PM_LS_LHEN_X2%4_c10 x_PM_LS_LHEN_X2%4_12 VSS 0.0113433f
C_x_PM_LS_LHEN_X2%4_c11 x_PM_LS_LHEN_X2%4_10 VSS 0.00890825f
C_x_PM_LS_LHEN_X2%4_c12 x_PM_LS_LHEN_X2%4_9 VSS 0.0335497f
C_x_PM_LS_LHEN_X2%4_c13 N_4_M1_g VSS 0.0324613f
C_x_PM_LS_LHEN_X2%4_c14 N_4_M8_g VSS 0.0352024f
R_x_PM_LS_LHEN_X2%4_r15 x_PM_LS_LHEN_X2%4_40 x_PM_LS_LHEN_X2%4_41 4.42
R_x_PM_LS_LHEN_X2%4_r16 x_PM_LS_LHEN_X2%4_38 x_PM_LS_LHEN_X2%4_40 0.78
R_x_PM_LS_LHEN_X2%4_r17 x_PM_LS_LHEN_X2%4_36 x_PM_LS_LHEN_X2%4_40 25.0012
R_x_PM_LS_LHEN_X2%4_r18 x_PM_LS_LHEN_X2%4_34 x_PM_LS_LHEN_X2%4_36 0.637857
R_x_PM_LS_LHEN_X2%4_r19 x_PM_LS_LHEN_X2%4_33 x_PM_LS_LHEN_X2%4_36 0.447857
R_x_PM_LS_LHEN_X2%4_r20 x_PM_LS_LHEN_X2%4_31 x_PM_LS_LHEN_X2%4_34 0.212317
R_x_PM_LS_LHEN_X2%4_r21 x_PM_LS_LHEN_X2%4_31 x_PM_LS_LHEN_X2%4_32 0.922857
R_x_PM_LS_LHEN_X2%4_r22 x_PM_LS_LHEN_X2%4_29 x_PM_LS_LHEN_X2%4_33 0.212317
R_x_PM_LS_LHEN_X2%4_r23 x_PM_LS_LHEN_X2%4_29 x_PM_LS_LHEN_X2%4_30 1.19429
R_x_PM_LS_LHEN_X2%4_r24 x_PM_LS_LHEN_X2%4_25 x_PM_LS_LHEN_X2%4_32 0.212317
R_x_PM_LS_LHEN_X2%4_r25 x_PM_LS_LHEN_X2%4_25 N_4_M0_s 0.285
R_x_PM_LS_LHEN_X2%4_r26 x_PM_LS_LHEN_X2%4_21 x_PM_LS_LHEN_X2%4_30 0.212317
R_x_PM_LS_LHEN_X2%4_r27 x_PM_LS_LHEN_X2%4_21 N_4_M7_s 0.637857
R_x_PM_LS_LHEN_X2%4_r28 x_PM_LS_LHEN_X2%4_15 N_4_M11_g 52.26
R_x_PM_LS_LHEN_X2%4_r29 x_PM_LS_LHEN_X2%4_13 x_PM_LS_LHEN_X2%4_15 4.58872
R_x_PM_LS_LHEN_X2%4_r30 x_PM_LS_LHEN_X2%4_13 x_PM_LS_LHEN_X2%4_14 53.04
R_x_PM_LS_LHEN_X2%4_r31 x_PM_LS_LHEN_X2%4_12 x_PM_LS_LHEN_X2%4_14 4.35808
R_x_PM_LS_LHEN_X2%4_r32 x_PM_LS_LHEN_X2%4_11 x_PM_LS_LHEN_X2%4_12 8.84
R_x_PM_LS_LHEN_X2%4_r33 x_PM_LS_LHEN_X2%4_10 x_PM_LS_LHEN_X2%4_41 2.6
R_x_PM_LS_LHEN_X2%4_r34 x_PM_LS_LHEN_X2%4_9 x_PM_LS_LHEN_X2%4_11 4.35808
R_x_PM_LS_LHEN_X2%4_r35 x_PM_LS_LHEN_X2%4_9 x_PM_LS_LHEN_X2%4_10 22.36
R_x_PM_LS_LHEN_X2%4_r36 x_PM_LS_LHEN_X2%4_5 x_PM_LS_LHEN_X2%4_41 1.95
R_x_PM_LS_LHEN_X2%4_r37 x_PM_LS_LHEN_X2%4_5 N_4_M1_g 34.32
R_x_PM_LS_LHEN_X2%4_r38 x_PM_LS_LHEN_X2%4_1 x_PM_LS_LHEN_X2%4_38 1.95
R_x_PM_LS_LHEN_X2%4_r39 x_PM_LS_LHEN_X2%4_1 N_4_M8_g 37.44
C_x_PM_LS_LHEN_X2%VDDL_c0 VDDL VSS 0.0627381f
C_x_PM_LS_LHEN_X2%VDDL_c1 x_PM_LS_LHEN_X2%VDDL_6 VSS 0.0577157f
R_x_PM_LS_LHEN_X2%VDDL_r2 N_VDDL_M0_b VDDL 0.18525
R_x_PM_LS_LHEN_X2%VDDL_r3 x_PM_LS_LHEN_X2%VDDL_7 N_VDDL_M0_b 0.0095
R_x_PM_LS_LHEN_X2%VDDL_r4 x_PM_LS_LHEN_X2%VDDL_6 x_PM_LS_LHEN_X2%VDDL_7 0.095
R_x_PM_LS_LHEN_X2%VDDL_r5 N_VDDL_M0_d x_PM_LS_LHEN_X2%VDDL_6 0.347287
C_x_PM_LS_LHEN_X2%6_c0 x_PM_LS_LHEN_X2%6_28 VSS 0.0130595f
C_x_PM_LS_LHEN_X2%6_c1 x_PM_LS_LHEN_X2%6_25 VSS 0.0168246f
C_x_PM_LS_LHEN_X2%6_c2 x_PM_LS_LHEN_X2%6_23 VSS 0.049992f
C_x_PM_LS_LHEN_X2%6_c3 x_PM_LS_LHEN_X2%6_17 VSS 0.0334979f
C_x_PM_LS_LHEN_X2%6_c4 x_PM_LS_LHEN_X2%6_13 VSS 0.046439f
C_x_PM_LS_LHEN_X2%6_c5 N_6_M1_d VSS 0.0322045f
C_x_PM_LS_LHEN_X2%6_c6 x_PM_LS_LHEN_X2%6_8 VSS 0.0615079f
C_x_PM_LS_LHEN_X2%6_c7 N_6_M10_g VSS 0.0262886f
R_x_PM_LS_LHEN_X2%6_r8 x_PM_LS_LHEN_X2%6_26 x_PM_LS_LHEN_X2%6_28 3.9
R_x_PM_LS_LHEN_X2%6_r9 N_6_M8_d x_PM_LS_LHEN_X2%6_23 0.257857
R_x_PM_LS_LHEN_X2%6_r10 x_PM_LS_LHEN_X2%6_17 x_PM_LS_LHEN_X2%6_26 25.0012
R_x_PM_LS_LHEN_X2%6_r11 x_PM_LS_LHEN_X2%6_15 x_PM_LS_LHEN_X2%6_17 0.583571
R_x_PM_LS_LHEN_X2%6_r12 x_PM_LS_LHEN_X2%6_14 x_PM_LS_LHEN_X2%6_25 0.0418175
R_x_PM_LS_LHEN_X2%6_r13 x_PM_LS_LHEN_X2%6_13 x_PM_LS_LHEN_X2%6_15 0.212317
R_x_PM_LS_LHEN_X2%6_r14 x_PM_LS_LHEN_X2%6_13 x_PM_LS_LHEN_X2%6_14 1.65571
R_x_PM_LS_LHEN_X2%6_r15 x_PM_LS_LHEN_X2%6_9 x_PM_LS_LHEN_X2%6_25 0.160909
R_x_PM_LS_LHEN_X2%6_r16 x_PM_LS_LHEN_X2%6_9 N_6_M1_d 0.637857
R_x_PM_LS_LHEN_X2%6_r17 x_PM_LS_LHEN_X2%6_8 x_PM_LS_LHEN_X2%6_25 0.160909
R_x_PM_LS_LHEN_X2%6_r18 x_PM_LS_LHEN_X2%6_7 x_PM_LS_LHEN_X2%6_23 0.095
R_x_PM_LS_LHEN_X2%6_r19 x_PM_LS_LHEN_X2%6_7 x_PM_LS_LHEN_X2%6_8 1.62857
R_x_PM_LS_LHEN_X2%6_r20 x_PM_LS_LHEN_X2%6_1 x_PM_LS_LHEN_X2%6_28 1.95
R_x_PM_LS_LHEN_X2%6_r21 x_PM_LS_LHEN_X2%6_1 N_6_M10_g 18.72
C_x_PM_LS_LHEN_X2%7_c0 x_PM_LS_LHEN_X2%7_23 VSS 0.0180574f
C_x_PM_LS_LHEN_X2%7_c1 x_PM_LS_LHEN_X2%7_20 VSS 0.00663771f
C_x_PM_LS_LHEN_X2%7_c2 x_PM_LS_LHEN_X2%7_16 VSS 0.047715f
C_x_PM_LS_LHEN_X2%7_c3 N_7_M2_s VSS 0.0588287f
C_x_PM_LS_LHEN_X2%7_c4 N_7_M10_d VSS 0.12033f
C_x_PM_LS_LHEN_X2%7_c5 N_7_M3_g VSS 0.0547966f
R_x_PM_LS_LHEN_X2%7_r6 x_PM_LS_LHEN_X2%7_18 x_PM_LS_LHEN_X2%7_23 5.98
R_x_PM_LS_LHEN_X2%7_r7 x_PM_LS_LHEN_X2%7_16 x_PM_LS_LHEN_X2%7_18 25.0012
R_x_PM_LS_LHEN_X2%7_r8 x_PM_LS_LHEN_X2%7_15 x_PM_LS_LHEN_X2%7_20 0.0418175
R_x_PM_LS_LHEN_X2%7_r9 x_PM_LS_LHEN_X2%7_15 x_PM_LS_LHEN_X2%7_16 0.827857
R_x_PM_LS_LHEN_X2%7_r10 x_PM_LS_LHEN_X2%7_11 x_PM_LS_LHEN_X2%7_20 0.160909
R_x_PM_LS_LHEN_X2%7_r11 x_PM_LS_LHEN_X2%7_7 x_PM_LS_LHEN_X2%7_20 0.160909
R_x_PM_LS_LHEN_X2%7_r12 x_PM_LS_LHEN_X2%7_7 N_7_M2_s 1.75071
R_x_PM_LS_LHEN_X2%7_r13 x_PM_LS_LHEN_X2%7_11 N_7_M10_d 2.67357
R_x_PM_LS_LHEN_X2%7_r14 x_PM_LS_LHEN_X2%7_1 x_PM_LS_LHEN_X2%7_23 1.95
R_x_PM_LS_LHEN_X2%7_r15 x_PM_LS_LHEN_X2%7_1 N_7_M3_g 54.99
C_x_PM_LS_LHEN_X2%8_c0 x_PM_LS_LHEN_X2%8_42 VSS 0.0100379f
C_x_PM_LS_LHEN_X2%8_c1 x_PM_LS_LHEN_X2%8_35 VSS 0.00585733f
C_x_PM_LS_LHEN_X2%8_c2 x_PM_LS_LHEN_X2%8_32 VSS 0.114098f
C_x_PM_LS_LHEN_X2%8_c3 N_8_M3_d VSS 0.030928f
C_x_PM_LS_LHEN_X2%8_c4 x_PM_LS_LHEN_X2%8_25 VSS 0.0362755f
C_x_PM_LS_LHEN_X2%8_c5 x_PM_LS_LHEN_X2%8_23 VSS 0.0193094f
C_x_PM_LS_LHEN_X2%8_c6 x_PM_LS_LHEN_X2%8_22 VSS 0.0121432f
C_x_PM_LS_LHEN_X2%8_c7 N_8_M11_s VSS 0.0590963f
C_x_PM_LS_LHEN_X2%8_c8 x_PM_LS_LHEN_X2%8_17 VSS 0.0789359f
C_x_PM_LS_LHEN_X2%8_c9 x_PM_LS_LHEN_X2%8_16 VSS 0.016132f
C_x_PM_LS_LHEN_X2%8_c10 N_8_M5_g VSS 0.069943f
C_x_PM_LS_LHEN_X2%8_c11 N_8_M14_g VSS 0.0465465f
C_x_PM_LS_LHEN_X2%8_c12 N_8_M2_g VSS 0.0335687f
R_x_PM_LS_LHEN_X2%8_r13 x_PM_LS_LHEN_X2%8_40 x_PM_LS_LHEN_X2%8_42 2.86
R_x_PM_LS_LHEN_X2%8_r14 x_PM_LS_LHEN_X2%8_32 x_PM_LS_LHEN_X2%8_40 25.0012
R_x_PM_LS_LHEN_X2%8_r15 x_PM_LS_LHEN_X2%8_30 x_PM_LS_LHEN_X2%8_32 3.135
R_x_PM_LS_LHEN_X2%8_r16 x_PM_LS_LHEN_X2%8_26 x_PM_LS_LHEN_X2%8_35 0.266978
R_x_PM_LS_LHEN_X2%8_r17 x_PM_LS_LHEN_X2%8_26 N_8_M3_d 0.583571
R_x_PM_LS_LHEN_X2%8_r18 x_PM_LS_LHEN_X2%8_25 x_PM_LS_LHEN_X2%8_35 0.266978
R_x_PM_LS_LHEN_X2%8_r19 x_PM_LS_LHEN_X2%8_24 x_PM_LS_LHEN_X2%8_30 0.095
R_x_PM_LS_LHEN_X2%8_r20 x_PM_LS_LHEN_X2%8_24 x_PM_LS_LHEN_X2%8_25 1.81857
R_x_PM_LS_LHEN_X2%8_r21 x_PM_LS_LHEN_X2%8_22 x_PM_LS_LHEN_X2%8_30 0.19
R_x_PM_LS_LHEN_X2%8_r22 x_PM_LS_LHEN_X2%8_22 x_PM_LS_LHEN_X2%8_23 0.732857
R_x_PM_LS_LHEN_X2%8_r23 x_PM_LS_LHEN_X2%8_18 x_PM_LS_LHEN_X2%8_23 0.212317
R_x_PM_LS_LHEN_X2%8_r24 x_PM_LS_LHEN_X2%8_18 N_8_M11_s 1.28929
R_x_PM_LS_LHEN_X2%8_r25 x_PM_LS_LHEN_X2%8_17 x_PM_LS_LHEN_X2%8_35 0.0272847
R_x_PM_LS_LHEN_X2%8_r26 x_PM_LS_LHEN_X2%8_36 x_PM_LS_LHEN_X2%8_16 4.42
R_x_PM_LS_LHEN_X2%8_r27 x_PM_LS_LHEN_X2%8_15 x_PM_LS_LHEN_X2%8_17 0.572472
R_x_PM_LS_LHEN_X2%8_r28 x_PM_LS_LHEN_X2%8_15 x_PM_LS_LHEN_X2%8_16 25.0012
R_x_PM_LS_LHEN_X2%8_r29 x_PM_LS_LHEN_X2%8_9 x_PM_LS_LHEN_X2%8_42 1.95
R_x_PM_LS_LHEN_X2%8_r30 x_PM_LS_LHEN_X2%8_9 N_8_M5_g 84.63
R_x_PM_LS_LHEN_X2%8_r31 x_PM_LS_LHEN_X2%8_5 x_PM_LS_LHEN_X2%8_42 1.95
R_x_PM_LS_LHEN_X2%8_r32 x_PM_LS_LHEN_X2%8_5 N_8_M14_g 47.58
R_x_PM_LS_LHEN_X2%8_r33 x_PM_LS_LHEN_X2%8_1 x_PM_LS_LHEN_X2%8_36 1.95
R_x_PM_LS_LHEN_X2%8_r34 x_PM_LS_LHEN_X2%8_1 N_8_M2_g 26.13
C_x_PM_LS_LHEN_X2%ISOLN_c0 ISOLN VSS 0.0327273f
C_x_PM_LS_LHEN_X2%ISOLN_c1 x_PM_LS_LHEN_X2%ISOLN_21 VSS 0.00441569f
C_x_PM_LS_LHEN_X2%ISOLN_c2 x_PM_LS_LHEN_X2%ISOLN_20 VSS 0.0243122f
C_x_PM_LS_LHEN_X2%ISOLN_c3 x_PM_LS_LHEN_X2%ISOLN_19 VSS 0.00894501f
C_x_PM_LS_LHEN_X2%ISOLN_c4 N_ISOLN_M4_g VSS 0.0520907f
C_x_PM_LS_LHEN_X2%ISOLN_c5 N_ISOLN_M13_g VSS 0.072415f
C_x_PM_LS_LHEN_X2%ISOLN_c6 N_ISOLN_M12_g VSS 0.0646441f
C_x_PM_LS_LHEN_X2%ISOLN_c7 x_PM_LS_LHEN_X2%ISOLN_6 VSS 0.0058849f
C_x_PM_LS_LHEN_X2%ISOLN_c8 x_PM_LS_LHEN_X2%ISOLN_5 VSS 0.0912043f
C_x_PM_LS_LHEN_X2%ISOLN_c9 N_ISOLN_M9_g VSS 0.0330452f
R_x_PM_LS_LHEN_X2%ISOLN_r10 x_PM_LS_LHEN_X2%ISOLN_22 x_PM_LS_LHEN_X2%ISOLN_24 25.0012
R_x_PM_LS_LHEN_X2%ISOLN_r11 x_PM_LS_LHEN_X2%ISOLN_22 ISOLN 0.183214
R_x_PM_LS_LHEN_X2%ISOLN_r12 x_PM_LS_LHEN_X2%ISOLN_20 x_PM_LS_LHEN_X2%ISOLN_24 14.82
R_x_PM_LS_LHEN_X2%ISOLN_r13 x_PM_LS_LHEN_X2%ISOLN_20 x_PM_LS_LHEN_X2%ISOLN_21 0.043368
R_x_PM_LS_LHEN_X2%ISOLN_r14 x_PM_LS_LHEN_X2%ISOLN_19 x_PM_LS_LHEN_X2%ISOLN_24 15.34
R_x_PM_LS_LHEN_X2%ISOLN_r15 x_PM_LS_LHEN_X2%ISOLN_15 x_PM_LS_LHEN_X2%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X2%ISOLN_r16 x_PM_LS_LHEN_X2%ISOLN_15 N_ISOLN_M4_g 56.55
R_x_PM_LS_LHEN_X2%ISOLN_r17 x_PM_LS_LHEN_X2%ISOLN_11 x_PM_LS_LHEN_X2%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X2%ISOLN_r18 x_PM_LS_LHEN_X2%ISOLN_11 N_ISOLN_M13_g 75.66
R_x_PM_LS_LHEN_X2%ISOLN_r19 x_PM_LS_LHEN_X2%ISOLN_8 x_PM_LS_LHEN_X2%ISOLN_19 4.58872
R_x_PM_LS_LHEN_X2%ISOLN_r20 x_PM_LS_LHEN_X2%ISOLN_8 N_ISOLN_M12_g 65.52
R_x_PM_LS_LHEN_X2%ISOLN_r21 x_PM_LS_LHEN_X2%ISOLN_7 N_ISOLN_M12_g 27.3
R_x_PM_LS_LHEN_X2%ISOLN_r22 x_PM_LS_LHEN_X2%ISOLN_5 x_PM_LS_LHEN_X2%ISOLN_7 4.35808
R_x_PM_LS_LHEN_X2%ISOLN_r23 x_PM_LS_LHEN_X2%ISOLN_5 x_PM_LS_LHEN_X2%ISOLN_6 104.52
R_x_PM_LS_LHEN_X2%ISOLN_r24 x_PM_LS_LHEN_X2%ISOLN_1 x_PM_LS_LHEN_X2%ISOLN_6 4.35808
R_x_PM_LS_LHEN_X2%ISOLN_r25 x_PM_LS_LHEN_X2%ISOLN_1 N_ISOLN_M9_g 27.3
C_x_PM_LS_LHEN_X2%10_c0 x_PM_LS_LHEN_X2%10_28 VSS 0.0133096f
C_x_PM_LS_LHEN_X2%10_c1 x_PM_LS_LHEN_X2%10_24 VSS 0.0958285f
C_x_PM_LS_LHEN_X2%10_c2 x_PM_LS_LHEN_X2%10_20 VSS 0.00757647f
C_x_PM_LS_LHEN_X2%10_c3 x_PM_LS_LHEN_X2%10_19 VSS 0.0319999f
C_x_PM_LS_LHEN_X2%10_c4 N_10_M4_d VSS 0.041437f
C_x_PM_LS_LHEN_X2%10_c5 x_PM_LS_LHEN_X2%10_14 VSS 0.016301f
C_x_PM_LS_LHEN_X2%10_c6 x_PM_LS_LHEN_X2%10_13 VSS 0.0837186f
C_x_PM_LS_LHEN_X2%10_c7 x_PM_LS_LHEN_X2%10_12 VSS 0.0404344f
C_x_PM_LS_LHEN_X2%10_c8 N_10_M6_g VSS 0.0650397f
C_x_PM_LS_LHEN_X2%10_c9 N_10_M15_g VSS 0.0547393f
R_x_PM_LS_LHEN_X2%10_r10 x_PM_LS_LHEN_X2%10_26 x_PM_LS_LHEN_X2%10_28 4.94
R_x_PM_LS_LHEN_X2%10_r11 x_PM_LS_LHEN_X2%10_24 x_PM_LS_LHEN_X2%10_26 25.0012
R_x_PM_LS_LHEN_X2%10_r12 x_PM_LS_LHEN_X2%10_22 x_PM_LS_LHEN_X2%10_24 1.09929
R_x_PM_LS_LHEN_X2%10_r13 x_PM_LS_LHEN_X2%10_21 x_PM_LS_LHEN_X2%10_24 1.045
R_x_PM_LS_LHEN_X2%10_r14 x_PM_LS_LHEN_X2%10_19 x_PM_LS_LHEN_X2%10_22 0.212317
R_x_PM_LS_LHEN_X2%10_r15 x_PM_LS_LHEN_X2%10_19 x_PM_LS_LHEN_X2%10_20 0.895714
R_x_PM_LS_LHEN_X2%10_r16 x_PM_LS_LHEN_X2%10_15 x_PM_LS_LHEN_X2%10_20 0.212317
R_x_PM_LS_LHEN_X2%10_r17 x_PM_LS_LHEN_X2%10_15 N_10_M4_d 1.15357
R_x_PM_LS_LHEN_X2%10_r18 x_PM_LS_LHEN_X2%10_13 x_PM_LS_LHEN_X2%10_21 0.212317
R_x_PM_LS_LHEN_X2%10_r19 x_PM_LS_LHEN_X2%10_13 x_PM_LS_LHEN_X2%10_14 1.9
R_x_PM_LS_LHEN_X2%10_r20 x_PM_LS_LHEN_X2%10_12 x_PM_LS_LHEN_X2%10_14 0.212317
R_x_PM_LS_LHEN_X2%10_r21 N_10_M13_s x_PM_LS_LHEN_X2%10_12 0.543196
R_x_PM_LS_LHEN_X2%10_r22 x_PM_LS_LHEN_X2%10_5 x_PM_LS_LHEN_X2%10_28 1.95
R_x_PM_LS_LHEN_X2%10_r23 x_PM_LS_LHEN_X2%10_5 N_10_M6_g 61.62
R_x_PM_LS_LHEN_X2%10_r24 x_PM_LS_LHEN_X2%10_1 x_PM_LS_LHEN_X2%10_28 1.95
R_x_PM_LS_LHEN_X2%10_r25 x_PM_LS_LHEN_X2%10_1 N_10_M15_g 56.16
C_x_PM_LS_LHEN_X2%Z_c0 N_Z_M15_d VSS 0.15161f
R_x_PM_LS_LHEN_X2%Z_r1 Z N_Z_M6_d 2.64643
R_x_PM_LS_LHEN_X2%Z_r2 N_Z_M15_d Z 1.91357
.ENDS

********************************************************************************
*
* END
*
********************************************************************************
