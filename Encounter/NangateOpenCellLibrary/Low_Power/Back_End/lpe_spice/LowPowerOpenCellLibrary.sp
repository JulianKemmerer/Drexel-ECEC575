*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2011, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *     NGLibraryCreator, v2010.08-HR32-SP3-2010-08-05 - build 1009061800      *
* *                                                                            *
* ******************************************************************************
*
*
* Running on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr).
* Local time is now Tue, 4 Jan 2011, 14:44:41.
* Main process id is 1680.
*
********************************************************************************
*                                                                              *
* Cellname:   AON_BUF_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AON_BUF_X1 VDD VSS A VDDBAK Z
*.PININFO VDD:P VSS:G A:I VDDBAK:P Z:O
*.EQN Z=A
M_M2 N_VDDBAK_M0_d N_A_M0_g N_5_M0_s VDD PMOS_VTL W=0.130000U L=0.050000U
M_M3 N_Z_M1_d N_5_M1_g N_VDDBAK_M0_d VDD PMOS_VTL W=0.130000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_5_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_5_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_AON_BUF_X1%VDD_c0 VSS x_PM_AON_BUF_X1%VDD_27 1.12209e-16
C_x_PM_AON_BUF_X1%VDD_c1 VSS x_PM_AON_BUF_X1%VDD_24 1.07528e-17
C_x_PM_AON_BUF_X1%VDD_c2 VSS x_PM_AON_BUF_X1%VDD_23 2.334e-16
C_x_PM_AON_BUF_X1%VDD_c3 VSS x_PM_AON_BUF_X1%VDD_14 2.61734e-16
C_x_PM_AON_BUF_X1%VDD_c4 VSS x_PM_AON_BUF_X1%VDD_11 1.92462e-17
C_x_PM_AON_BUF_X1%VDD_c5 VSS x_PM_AON_BUF_X1%VDD_7 6.16516e-16
R_x_PM_AON_BUF_X1%VDD_r6 x_PM_AON_BUF_X1%VDD_27 x_PM_AON_BUF_X1%VDD_25 0.13879
R_x_PM_AON_BUF_X1%VDD_r7 x_PM_AON_BUF_X1%VDD_24 x_PM_AON_BUF_X1%VDD_27 3.17412
R_x_PM_AON_BUF_X1%VDD_r8 x_PM_AON_BUF_X1%VDD_24 x_PM_AON_BUF_X1%VDD_25 0.138595
R_x_PM_AON_BUF_X1%VDD_r9 x_PM_AON_BUF_X1%VDD_23 x_PM_AON_BUF_X1%VDD_25 0.138985
R_x_PM_AON_BUF_X1%VDD_r10 x_PM_AON_BUF_X1%VDD_14 x_PM_AON_BUF_X1%VDD_25 0.13879
R_x_PM_AON_BUF_X1%VDD_r11 VDD x_PM_AON_BUF_X1%VDD_14 3.84471
R_x_PM_AON_BUF_X1%VDD_r12 x_PM_AON_BUF_X1%VDD_25 x_PM_AON_BUF_X1%VDD_11 0.140282
R_x_PM_AON_BUF_X1%VDD_r13 x_PM_AON_BUF_X1%VDD_11 x_PM_AON_BUF_X1%VDD_23 7.68941
R_x_PM_AON_BUF_X1%VDD_r14 VDD x_PM_AON_BUF_X1%VDD_7 9.57824
C_x_PM_AON_BUF_X1%VSS_c0 VSS VSS 2.61603e-16
C_x_PM_AON_BUF_X1%VSS_c1 VSS x_PM_AON_BUF_X1%VSS_31 2.334e-16
C_x_PM_AON_BUF_X1%VSS_c2 VSS x_PM_AON_BUF_X1%VSS_21 5.61189e-17
C_x_PM_AON_BUF_X1%VSS_c3 VSS N_VSS_M2_d 6.2708e-17
C_x_PM_AON_BUF_X1%VSS_c4 VSS VSS 5.64863e-18
C_x_PM_AON_BUF_X1%VSS_c5 VSS x_PM_AON_BUF_X1%VSS_14 1.06204e-17
C_x_PM_AON_BUF_X1%VSS_c6 VSS x_PM_AON_BUF_X1%VSS_13 5.94309e-17
C_x_PM_AON_BUF_X1%VSS_c7 VSS x_PM_AON_BUF_X1%VSS_10 6.16516e-16
C_x_PM_AON_BUF_X1%VSS_c8 VSS x_PM_AON_BUF_X1%VSS_9 1.92462e-17
R_x_PM_AON_BUF_X1%VSS_r9 x_PM_AON_BUF_X1%VSS_31 VSS 0.138985
R_x_PM_AON_BUF_X1%VSS_r10 x_PM_AON_BUF_X1%VSS_21 VSS 0.13879
R_x_PM_AON_BUF_X1%VSS_r11 x_PM_AON_BUF_X1%VSS_22 x_PM_AON_BUF_X1%VSS_21 1.44176
R_x_PM_AON_BUF_X1%VSS_r12 N_VSS_M2_d VSS 0.372963
R_x_PM_AON_BUF_X1%VSS_r13 VSS x_PM_AON_BUF_X1%VSS_22 0.132285
R_x_PM_AON_BUF_X1%VSS_r14 x_PM_AON_BUF_X1%VSS_14 VSS 0.138595
R_x_PM_AON_BUF_X1%VSS_r15 VSS x_PM_AON_BUF_X1%VSS_13 0.132285
R_x_PM_AON_BUF_X1%VSS_r16 x_PM_AON_BUF_X1%VSS_14 x_PM_AON_BUF_X1%VSS_13 1.43059
R_x_PM_AON_BUF_X1%VSS_r17 VSS x_PM_AON_BUF_X1%VSS_10 9.57824
R_x_PM_AON_BUF_X1%VSS_r18 VSS x_PM_AON_BUF_X1%VSS_9 0.140282
R_x_PM_AON_BUF_X1%VSS_r19 x_PM_AON_BUF_X1%VSS_9 x_PM_AON_BUF_X1%VSS_31 7.68941
C_x_PM_AON_BUF_X1%A_c0 VSS x_PM_AON_BUF_X1%A_20 8.83408e-18
C_x_PM_AON_BUF_X1%A_c1 VSS x_PM_AON_BUF_X1%A_14 7.3604e-17
C_x_PM_AON_BUF_X1%A_c2 VSS A 2.41117e-17
C_x_PM_AON_BUF_X1%A_c3 VSS N_A_M0_g 3.90814e-17
C_x_PM_AON_BUF_X1%A_c4 VSS N_A_M2_g 3.98134e-17
R_x_PM_AON_BUF_X1%A_r5 x_PM_AON_BUF_X1%A_20 x_PM_AON_BUF_X1%A_16 2.34
R_x_PM_AON_BUF_X1%A_r6 x_PM_AON_BUF_X1%A_16 x_PM_AON_BUF_X1%A_14 25.0012
R_x_PM_AON_BUF_X1%A_r7 x_PM_AON_BUF_X1%A_14 A 0.393571
R_x_PM_AON_BUF_X1%A_r8 x_PM_AON_BUF_X1%A_20 x_PM_AON_BUF_X1%A_5 1.95
R_x_PM_AON_BUF_X1%A_r9 N_A_M0_g x_PM_AON_BUF_X1%A_5 33.54
R_x_PM_AON_BUF_X1%A_r10 x_PM_AON_BUF_X1%A_20 x_PM_AON_BUF_X1%A_1 1.95
R_x_PM_AON_BUF_X1%A_r11 N_A_M2_g x_PM_AON_BUF_X1%A_1 35.1
C_x_PM_AON_BUF_X1%VDDBAK_c0 VSS VDDBAK 4.42696e-17
C_x_PM_AON_BUF_X1%VDDBAK_c1 VSS VDD 3.25091e-17
C_x_PM_AON_BUF_X1%VDDBAK_c2 VSS x_PM_AON_BUF_X1%VDDBAK_8 5.65445e-17
R_x_PM_AON_BUF_X1%VDDBAK_r3 VDDBAK x_PM_AON_BUF_X1%VDDBAK_9 0.114722
R_x_PM_AON_BUF_X1%VDDBAK_r4 VDD x_PM_AON_BUF_X1%VDDBAK_9 0.00475
R_x_PM_AON_BUF_X1%VDDBAK_r5 VDDBAK x_PM_AON_BUF_X1%VDDBAK_8 0.08688
R_x_PM_AON_BUF_X1%VDDBAK_r6 x_PM_AON_BUF_X1%VDDBAK_8 N_VDDBAK_M0_d 0.361361
C_x_PM_AON_BUF_X1%5_c0 VSS x_PM_AON_BUF_X1%5_30 1.24829e-17
C_x_PM_AON_BUF_X1%5_c1 VSS x_PM_AON_BUF_X1%5_26 6.86318e-17
C_x_PM_AON_BUF_X1%5_c2 VSS x_PM_AON_BUF_X1%5_22 1.52816e-17
C_x_PM_AON_BUF_X1%5_c3 VSS x_PM_AON_BUF_X1%5_21 6.41733e-17
C_x_PM_AON_BUF_X1%5_c4 VSS x_PM_AON_BUF_X1%5_20 2.1121e-17
C_x_PM_AON_BUF_X1%5_c5 VSS x_PM_AON_BUF_X1%5_19 6.6955e-17
C_x_PM_AON_BUF_X1%5_c6 VSS N_5_M0_s 1.93072e-17
C_x_PM_AON_BUF_X1%5_c7 VSS N_5_M2_s 3.41594e-17
C_x_PM_AON_BUF_X1%5_c8 VSS N_5_M1_g 4.18204e-17
C_x_PM_AON_BUF_X1%5_c9 VSS N_5_M3_g 3.50265e-17
R_x_PM_AON_BUF_X1%5_r10 x_PM_AON_BUF_X1%5_30 x_PM_AON_BUF_X1%5_28 3.9
R_x_PM_AON_BUF_X1%5_r11 x_PM_AON_BUF_X1%5_28 x_PM_AON_BUF_X1%5_26 25.0012
R_x_PM_AON_BUF_X1%5_r12 x_PM_AON_BUF_X1%5_26 x_PM_AON_BUF_X1%5_24 0.773571
R_x_PM_AON_BUF_X1%5_r13 x_PM_AON_BUF_X1%5_26 x_PM_AON_BUF_X1%5_23 0.366429
R_x_PM_AON_BUF_X1%5_r14 x_PM_AON_BUF_X1%5_24 x_PM_AON_BUF_X1%5_21 0.212317
R_x_PM_AON_BUF_X1%5_r15 x_PM_AON_BUF_X1%5_22 x_PM_AON_BUF_X1%5_21 0.95
R_x_PM_AON_BUF_X1%5_r16 x_PM_AON_BUF_X1%5_23 x_PM_AON_BUF_X1%5_19 0.212317
R_x_PM_AON_BUF_X1%5_r17 x_PM_AON_BUF_X1%5_20 x_PM_AON_BUF_X1%5_19 0.95
R_x_PM_AON_BUF_X1%5_r18 x_PM_AON_BUF_X1%5_22 x_PM_AON_BUF_X1%5_15 0.212317
R_x_PM_AON_BUF_X1%5_r19 N_5_M0_s x_PM_AON_BUF_X1%5_15 0.312143
R_x_PM_AON_BUF_X1%5_r20 x_PM_AON_BUF_X1%5_20 x_PM_AON_BUF_X1%5_11 0.212317
R_x_PM_AON_BUF_X1%5_r21 N_5_M2_s x_PM_AON_BUF_X1%5_11 0.475
R_x_PM_AON_BUF_X1%5_r22 x_PM_AON_BUF_X1%5_30 x_PM_AON_BUF_X1%5_5 1.95
R_x_PM_AON_BUF_X1%5_r23 N_5_M1_g x_PM_AON_BUF_X1%5_5 39
R_x_PM_AON_BUF_X1%5_r24 x_PM_AON_BUF_X1%5_30 x_PM_AON_BUF_X1%5_1 1.95
R_x_PM_AON_BUF_X1%5_r25 N_5_M3_g x_PM_AON_BUF_X1%5_1 29.64
C_x_PM_AON_BUF_X1%Z_c0 VSS N_Z_M3_d 1.23436e-16
R_x_PM_AON_BUF_X1%Z_r1 N_Z_M1_d Z 1.26214
R_x_PM_AON_BUF_X1%Z_r2 Z N_Z_M3_d 1.45214
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AON_BUF_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AON_BUF_X2 VDD VSS A VDDBAK Z
*.PININFO VDD:P VSS:G A:I VDDBAK:P Z:O
*.EQN Z=A
M_M2 N_VDDBAK_M0_d N_A_M0_g N_5_M0_s VDD PMOS_VTL W=0.130000U L=0.050000U
M_M3 N_Z_M1_d N_5_M1_g N_VDDBAK_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_5_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_5_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AON_BUF_X2%VDD_c0 VSS x_PM_AON_BUF_X2%VDD_27 1.12297e-16
C_x_PM_AON_BUF_X2%VDD_c1 VSS x_PM_AON_BUF_X2%VDD_24 1.07528e-17
C_x_PM_AON_BUF_X2%VDD_c2 VSS x_PM_AON_BUF_X2%VDD_23 2.334e-16
C_x_PM_AON_BUF_X2%VDD_c3 VSS x_PM_AON_BUF_X2%VDD_14 2.61734e-16
C_x_PM_AON_BUF_X2%VDD_c4 VSS x_PM_AON_BUF_X2%VDD_11 1.92462e-17
C_x_PM_AON_BUF_X2%VDD_c5 VSS x_PM_AON_BUF_X2%VDD_7 6.16516e-16
R_x_PM_AON_BUF_X2%VDD_r6 x_PM_AON_BUF_X2%VDD_27 x_PM_AON_BUF_X2%VDD_25 0.13879
R_x_PM_AON_BUF_X2%VDD_r7 x_PM_AON_BUF_X2%VDD_24 x_PM_AON_BUF_X2%VDD_27 3.17412
R_x_PM_AON_BUF_X2%VDD_r8 x_PM_AON_BUF_X2%VDD_24 x_PM_AON_BUF_X2%VDD_25 0.138595
R_x_PM_AON_BUF_X2%VDD_r9 x_PM_AON_BUF_X2%VDD_23 x_PM_AON_BUF_X2%VDD_25 0.138985
R_x_PM_AON_BUF_X2%VDD_r10 x_PM_AON_BUF_X2%VDD_14 x_PM_AON_BUF_X2%VDD_25 0.13879
R_x_PM_AON_BUF_X2%VDD_r11 VDD x_PM_AON_BUF_X2%VDD_14 3.84471
R_x_PM_AON_BUF_X2%VDD_r12 x_PM_AON_BUF_X2%VDD_25 x_PM_AON_BUF_X2%VDD_11 0.140282
R_x_PM_AON_BUF_X2%VDD_r13 x_PM_AON_BUF_X2%VDD_11 x_PM_AON_BUF_X2%VDD_23 7.68941
R_x_PM_AON_BUF_X2%VDD_r14 VDD x_PM_AON_BUF_X2%VDD_7 9.57824
C_x_PM_AON_BUF_X2%VSS_c0 VSS VSS 2.61606e-16
C_x_PM_AON_BUF_X2%VSS_c1 VSS x_PM_AON_BUF_X2%VSS_31 2.334e-16
C_x_PM_AON_BUF_X2%VSS_c2 VSS x_PM_AON_BUF_X2%VSS_21 4.97959e-17
C_x_PM_AON_BUF_X2%VSS_c3 VSS N_VSS_M2_d 3.1961e-17
C_x_PM_AON_BUF_X2%VSS_c4 VSS VSS 5.64012e-18
C_x_PM_AON_BUF_X2%VSS_c5 VSS x_PM_AON_BUF_X2%VSS_14 1.06175e-17
C_x_PM_AON_BUF_X2%VSS_c6 VSS x_PM_AON_BUF_X2%VSS_13 5.66356e-17
C_x_PM_AON_BUF_X2%VSS_c7 VSS x_PM_AON_BUF_X2%VSS_10 6.16516e-16
C_x_PM_AON_BUF_X2%VSS_c8 VSS x_PM_AON_BUF_X2%VSS_9 1.92462e-17
R_x_PM_AON_BUF_X2%VSS_r9 x_PM_AON_BUF_X2%VSS_31 VSS 0.138985
R_x_PM_AON_BUF_X2%VSS_r10 x_PM_AON_BUF_X2%VSS_21 VSS 0.13879
R_x_PM_AON_BUF_X2%VSS_r11 x_PM_AON_BUF_X2%VSS_22 x_PM_AON_BUF_X2%VSS_21 1.46412
R_x_PM_AON_BUF_X2%VSS_r12 N_VSS_M2_d VSS 0.344815
R_x_PM_AON_BUF_X2%VSS_r13 VSS x_PM_AON_BUF_X2%VSS_22 0.132285
R_x_PM_AON_BUF_X2%VSS_r14 x_PM_AON_BUF_X2%VSS_14 VSS 0.138595
R_x_PM_AON_BUF_X2%VSS_r15 VSS x_PM_AON_BUF_X2%VSS_13 0.132285
R_x_PM_AON_BUF_X2%VSS_r16 x_PM_AON_BUF_X2%VSS_14 x_PM_AON_BUF_X2%VSS_13 1.40824
R_x_PM_AON_BUF_X2%VSS_r17 VSS x_PM_AON_BUF_X2%VSS_10 9.57824
R_x_PM_AON_BUF_X2%VSS_r18 VSS x_PM_AON_BUF_X2%VSS_9 0.140282
R_x_PM_AON_BUF_X2%VSS_r19 x_PM_AON_BUF_X2%VSS_9 x_PM_AON_BUF_X2%VSS_31 7.68941
C_x_PM_AON_BUF_X2%A_c0 VSS x_PM_AON_BUF_X2%A_14 3.37828e-17
C_x_PM_AON_BUF_X2%A_c1 VSS x_PM_AON_BUF_X2%A_10 6.37945e-18
C_x_PM_AON_BUF_X2%A_c2 VSS x_PM_AON_BUF_X2%A_9 2.68922e-17
C_x_PM_AON_BUF_X2%A_c3 VSS N_A_M0_g 4.02904e-17
C_x_PM_AON_BUF_X2%A_c4 VSS N_A_M2_g 4.04946e-17
R_x_PM_AON_BUF_X2%A_r5 x_PM_AON_BUF_X2%A_16 x_PM_AON_BUF_X2%A_14 25.0012
R_x_PM_AON_BUF_X2%A_r6 x_PM_AON_BUF_X2%A_14 A 0.074643
R_x_PM_AON_BUF_X2%A_r7 x_PM_AON_BUF_X2%A_16 x_PM_AON_BUF_X2%A_9 20.54
R_x_PM_AON_BUF_X2%A_r8 x_PM_AON_BUF_X2%A_10 x_PM_AON_BUF_X2%A_9 0.043368
R_x_PM_AON_BUF_X2%A_r9 x_PM_AON_BUF_X2%A_10 x_PM_AON_BUF_X2%A_5 4.56151
R_x_PM_AON_BUF_X2%A_r10 N_A_M0_g x_PM_AON_BUF_X2%A_5 33.54
R_x_PM_AON_BUF_X2%A_r11 x_PM_AON_BUF_X2%A_10 x_PM_AON_BUF_X2%A_1 4.56151
R_x_PM_AON_BUF_X2%A_r12 N_A_M2_g x_PM_AON_BUF_X2%A_1 36.66
C_x_PM_AON_BUF_X2%VDDBAK_c0 VSS x_PM_AON_BUF_X2%VDDBAK_18 5.3983e-18
C_x_PM_AON_BUF_X2%VDDBAK_c1 VSS VDDBAK 4.12356e-17
C_x_PM_AON_BUF_X2%VDDBAK_c2 VSS N_VDDBAK_M0_d 4.00218e-17
C_x_PM_AON_BUF_X2%VDDBAK_c3 VSS x_PM_AON_BUF_X2%VDDBAK_5 3.76042e-17
R_x_PM_AON_BUF_X2%VDDBAK_r4 x_PM_AON_BUF_X2%VDDBAK_18 x_PM_AON_BUF_X2%VDDBAK_14 0.062814
R_x_PM_AON_BUF_X2%VDDBAK_r5 VDDBAK x_PM_AON_BUF_X2%VDDBAK_14 0.0855
R_x_PM_AON_BUF_X2%VDDBAK_r6 x_PM_AON_BUF_X2%VDDBAK_18 x_PM_AON_BUF_X2%VDDBAK_10 0.164712
R_x_PM_AON_BUF_X2%VDDBAK_r7 N_VDDBAK_M0_d x_PM_AON_BUF_X2%VDDBAK_10 0.122143
R_x_PM_AON_BUF_X2%VDDBAK_r8 x_PM_AON_BUF_X2%VDDBAK_18 x_PM_AON_BUF_X2%VDDBAK_5 0.062814
R_x_PM_AON_BUF_X2%VDDBAK_r9 VDD x_PM_AON_BUF_X2%VDDBAK_5 0.34675
C_x_PM_AON_BUF_X2%5_c0 VSS x_PM_AON_BUF_X2%5_25 1.15669e-17
C_x_PM_AON_BUF_X2%5_c1 VSS x_PM_AON_BUF_X2%5_22 2.97856e-17
C_x_PM_AON_BUF_X2%5_c2 VSS x_PM_AON_BUF_X2%5_21 6.5443e-17
C_x_PM_AON_BUF_X2%5_c3 VSS N_5_M0_s 2.45409e-17
C_x_PM_AON_BUF_X2%5_c4 VSS N_5_M2_s 5.07211e-17
C_x_PM_AON_BUF_X2%5_c5 VSS N_5_M1_g 4.95926e-17
C_x_PM_AON_BUF_X2%5_c6 VSS N_5_M3_g 4.21234e-17
R_x_PM_AON_BUF_X2%5_r7 x_PM_AON_BUF_X2%5_25 x_PM_AON_BUF_X2%5_23 3.9
R_x_PM_AON_BUF_X2%5_r8 x_PM_AON_BUF_X2%5_22 x_PM_AON_BUF_X2%5_21 0.027285
R_x_PM_AON_BUF_X2%5_r9 x_PM_AON_BUF_X2%5_21 x_PM_AON_BUF_X2%5_19 0.614694
R_x_PM_AON_BUF_X2%5_r10 x_PM_AON_BUF_X2%5_23 x_PM_AON_BUF_X2%5_19 25.0012
R_x_PM_AON_BUF_X2%5_r11 x_PM_AON_BUF_X2%5_22 x_PM_AON_BUF_X2%5_15 0.266978
R_x_PM_AON_BUF_X2%5_r12 N_5_M0_s x_PM_AON_BUF_X2%5_15 0.692143
R_x_PM_AON_BUF_X2%5_r13 x_PM_AON_BUF_X2%5_22 x_PM_AON_BUF_X2%5_11 0.266978
R_x_PM_AON_BUF_X2%5_r14 N_5_M2_s x_PM_AON_BUF_X2%5_11 1.28929
R_x_PM_AON_BUF_X2%5_r15 x_PM_AON_BUF_X2%5_25 x_PM_AON_BUF_X2%5_5 1.95
R_x_PM_AON_BUF_X2%5_r16 N_5_M1_g x_PM_AON_BUF_X2%5_5 38.22
R_x_PM_AON_BUF_X2%5_r17 x_PM_AON_BUF_X2%5_25 x_PM_AON_BUF_X2%5_1 1.95
R_x_PM_AON_BUF_X2%5_r18 N_5_M3_g x_PM_AON_BUF_X2%5_1 35.88
C_x_PM_AON_BUF_X2%Z_c0 VSS N_Z_M3_d 8.62088e-17
R_x_PM_AON_BUF_X2%Z_r1 N_Z_M1_d Z 1.45214
R_x_PM_AON_BUF_X2%Z_r2 Z N_Z_M3_d 1.12643
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AON_BUF_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AON_BUF_X4 VDD VSS A VDDBAK Z
*.PININFO VDD:P VSS:G A:I VDDBAK:P Z:O
*.EQN Z=A
M_M3 N_VDDBAK_M0_d N_A_M0_g N_5_M0_s VDD PMOS_VTL W=0.130000U L=0.050000U
M_M4 N_Z_M1_d N_5_M1_g N_VDDBAK_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M5 N_VDDBAK_M2_d N_5_M2_g N_Z_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M3_d N_A_M3_g N_5_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M4_d N_5_M4_g N_VSS_M3_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_VSS_M5_d N_5_M5_g N_Z_M4_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AON_BUF_X4%VDD_c0 VSS x_PM_AON_BUF_X4%VDD_27 1.30918e-16
C_x_PM_AON_BUF_X4%VDD_c1 VSS x_PM_AON_BUF_X4%VDD_24 1.08319e-17
C_x_PM_AON_BUF_X4%VDD_c2 VSS x_PM_AON_BUF_X4%VDD_23 2.334e-16
C_x_PM_AON_BUF_X4%VDD_c3 VSS x_PM_AON_BUF_X4%VDD_14 2.61813e-16
C_x_PM_AON_BUF_X4%VDD_c4 VSS x_PM_AON_BUF_X4%VDD_11 1.92462e-17
C_x_PM_AON_BUF_X4%VDD_c5 VSS x_PM_AON_BUF_X4%VDD_7 6.2937e-16
R_x_PM_AON_BUF_X4%VDD_r6 x_PM_AON_BUF_X4%VDD_27 x_PM_AON_BUF_X4%VDD_25 0.13879
R_x_PM_AON_BUF_X4%VDD_r7 x_PM_AON_BUF_X4%VDD_24 x_PM_AON_BUF_X4%VDD_27 3.59882
R_x_PM_AON_BUF_X4%VDD_r8 x_PM_AON_BUF_X4%VDD_24 x_PM_AON_BUF_X4%VDD_25 0.138595
R_x_PM_AON_BUF_X4%VDD_r9 x_PM_AON_BUF_X4%VDD_23 x_PM_AON_BUF_X4%VDD_25 0.138985
R_x_PM_AON_BUF_X4%VDD_r10 x_PM_AON_BUF_X4%VDD_14 x_PM_AON_BUF_X4%VDD_25 0.13879
R_x_PM_AON_BUF_X4%VDD_r11 VDD x_PM_AON_BUF_X4%VDD_14 3.84471
R_x_PM_AON_BUF_X4%VDD_r12 x_PM_AON_BUF_X4%VDD_25 x_PM_AON_BUF_X4%VDD_11 0.140282
R_x_PM_AON_BUF_X4%VDD_r13 x_PM_AON_BUF_X4%VDD_11 x_PM_AON_BUF_X4%VDD_23 7.68941
R_x_PM_AON_BUF_X4%VDD_r14 VDD x_PM_AON_BUF_X4%VDD_7 9.79059
C_x_PM_AON_BUF_X4%VSS_c0 VSS x_PM_AON_BUF_X4%VSS_44 2.98416e-17
C_x_PM_AON_BUF_X4%VSS_c1 VSS x_PM_AON_BUF_X4%VSS_41 2.9415e-18
C_x_PM_AON_BUF_X4%VSS_c2 VSS x_PM_AON_BUF_X4%VSS_38 2.334e-16
C_x_PM_AON_BUF_X4%VSS_c3 VSS VSS 2.61533e-16
C_x_PM_AON_BUF_X4%VSS_c4 VSS N_VSS_M5_d 1.7593e-17
C_x_PM_AON_BUF_X4%VSS_c5 VSS x_PM_AON_BUF_X4%VSS_22 2.05739e-17
C_x_PM_AON_BUF_X4%VSS_c6 VSS N_VSS_M3_d 5.04832e-17
C_x_PM_AON_BUF_X4%VSS_c7 VSS VSS 5.64012e-18
C_x_PM_AON_BUF_X4%VSS_c8 VSS x_PM_AON_BUF_X4%VSS_15 1.06344e-17
C_x_PM_AON_BUF_X4%VSS_c9 VSS x_PM_AON_BUF_X4%VSS_14 6.21346e-17
C_x_PM_AON_BUF_X4%VSS_c10 VSS x_PM_AON_BUF_X4%VSS_11 6.2937e-16
C_x_PM_AON_BUF_X4%VSS_c11 VSS x_PM_AON_BUF_X4%VSS_10 1.92462e-17
R_x_PM_AON_BUF_X4%VSS_r12 x_PM_AON_BUF_X4%VSS_44 VSS 0.13879
R_x_PM_AON_BUF_X4%VSS_r13 x_PM_AON_BUF_X4%VSS_38 VSS 0.138985
R_x_PM_AON_BUF_X4%VSS_r14 x_PM_AON_BUF_X4%VSS_41 x_PM_AON_BUF_X4%VSS_29 0.073144
R_x_PM_AON_BUF_X4%VSS_r15 x_PM_AON_BUF_X4%VSS_29 x_PM_AON_BUF_X4%VSS_44 0.983529
R_x_PM_AON_BUF_X4%VSS_r16 x_PM_AON_BUF_X4%VSS_41 x_PM_AON_BUF_X4%VSS_24 0.145286
R_x_PM_AON_BUF_X4%VSS_r17 N_VSS_M5_d x_PM_AON_BUF_X4%VSS_24 0.692143
R_x_PM_AON_BUF_X4%VSS_r18 x_PM_AON_BUF_X4%VSS_41 x_PM_AON_BUF_X4%VSS_22 0.073144
R_x_PM_AON_BUF_X4%VSS_r19 x_PM_AON_BUF_X4%VSS_23 x_PM_AON_BUF_X4%VSS_22 0.614706
R_x_PM_AON_BUF_X4%VSS_r20 N_VSS_M3_d VSS 0.344815
R_x_PM_AON_BUF_X4%VSS_r21 VSS x_PM_AON_BUF_X4%VSS_23 0.132285
R_x_PM_AON_BUF_X4%VSS_r22 x_PM_AON_BUF_X4%VSS_15 VSS 0.138595
R_x_PM_AON_BUF_X4%VSS_r23 VSS x_PM_AON_BUF_X4%VSS_14 0.132285
R_x_PM_AON_BUF_X4%VSS_r24 x_PM_AON_BUF_X4%VSS_15 x_PM_AON_BUF_X4%VSS_14 1.54235
R_x_PM_AON_BUF_X4%VSS_r25 VSS x_PM_AON_BUF_X4%VSS_11 9.79059
R_x_PM_AON_BUF_X4%VSS_r26 VSS x_PM_AON_BUF_X4%VSS_10 0.140282
R_x_PM_AON_BUF_X4%VSS_r27 x_PM_AON_BUF_X4%VSS_10 x_PM_AON_BUF_X4%VSS_38 7.68941
C_x_PM_AON_BUF_X4%A_c0 VSS A 1.20768e-17
C_x_PM_AON_BUF_X4%A_c1 VSS x_PM_AON_BUF_X4%A_12 7.23073e-18
C_x_PM_AON_BUF_X4%A_c2 VSS x_PM_AON_BUF_X4%A_10 5.40203e-17
C_x_PM_AON_BUF_X4%A_c3 VSS N_A_M0_g 3.1377e-17
C_x_PM_AON_BUF_X4%A_c4 VSS N_A_M3_g 4.34278e-17
R_x_PM_AON_BUF_X4%A_r5 x_PM_AON_BUF_X4%A_17 A 0.156471
R_x_PM_AON_BUF_X4%A_r6 x_PM_AON_BUF_X4%A_21 x_PM_AON_BUF_X4%A_12 4.7687
R_x_PM_AON_BUF_X4%A_r7 x_PM_AON_BUF_X4%A_20 x_PM_AON_BUF_X4%A_12 4.7687
R_x_PM_AON_BUF_X4%A_r8 x_PM_AON_BUF_X4%A_12 x_PM_AON_BUF_X4%A_10 25.0012
R_x_PM_AON_BUF_X4%A_r9 x_PM_AON_BUF_X4%A_17 x_PM_AON_BUF_X4%A_9 0.095
R_x_PM_AON_BUF_X4%A_r10 x_PM_AON_BUF_X4%A_10 x_PM_AON_BUF_X4%A_9 1.37071
R_x_PM_AON_BUF_X4%A_r11 N_A_M0_g x_PM_AON_BUF_X4%A_21 26.52
R_x_PM_AON_BUF_X4%A_r12 N_A_M3_g x_PM_AON_BUF_X4%A_20 42.12
C_x_PM_AON_BUF_X4%VDDBAK_c0 VSS x_PM_AON_BUF_X4%VDDBAK_23 5.13945e-18
C_x_PM_AON_BUF_X4%VDDBAK_c1 VSS N_VDDBAK_M2_d 2.71795e-17
C_x_PM_AON_BUF_X4%VDDBAK_c2 VSS x_PM_AON_BUF_X4%VDDBAK_15 5.77055e-17
C_x_PM_AON_BUF_X4%VDDBAK_c3 VSS N_VDDBAK_M0_d 2.04449e-17
C_x_PM_AON_BUF_X4%VDDBAK_c4 VSS x_PM_AON_BUF_X4%VDDBAK_6 4.51549e-17
R_x_PM_AON_BUF_X4%VDDBAK_r5 N_VDDBAK_M2_d x_PM_AON_BUF_X4%VDDBAK_19 0.230714
R_x_PM_AON_BUF_X4%VDDBAK_r6 x_PM_AON_BUF_X4%VDDBAK_23 x_PM_AON_BUF_X4%VDDBAK_16 0.062814
R_x_PM_AON_BUF_X4%VDDBAK_r7 VDDBAK x_PM_AON_BUF_X4%VDDBAK_16 0.114
R_x_PM_AON_BUF_X4%VDDBAK_r8 x_PM_AON_BUF_X4%VDDBAK_19 x_PM_AON_BUF_X4%VDDBAK_15 0.283756
R_x_PM_AON_BUF_X4%VDDBAK_r9 VDDBAK x_PM_AON_BUF_X4%VDDBAK_15 0.475
R_x_PM_AON_BUF_X4%VDDBAK_r10 x_PM_AON_BUF_X4%VDDBAK_23 x_PM_AON_BUF_X4%VDDBAK_11 0.164712
R_x_PM_AON_BUF_X4%VDDBAK_r11 N_VDDBAK_M0_d x_PM_AON_BUF_X4%VDDBAK_11 0.230714
R_x_PM_AON_BUF_X4%VDDBAK_r12 x_PM_AON_BUF_X4%VDDBAK_23 x_PM_AON_BUF_X4%VDDBAK_6 0.062814
R_x_PM_AON_BUF_X4%VDDBAK_r13 VDD x_PM_AON_BUF_X4%VDDBAK_6 0.45125
C_x_PM_AON_BUF_X4%5_c0 VSS x_PM_AON_BUF_X4%5_35 8.29552e-17
C_x_PM_AON_BUF_X4%5_c1 VSS x_PM_AON_BUF_X4%5_31 9.30985e-18
C_x_PM_AON_BUF_X4%5_c2 VSS x_PM_AON_BUF_X4%5_30 6.15894e-17
C_x_PM_AON_BUF_X4%5_c3 VSS N_5_M3_s 2.84308e-17
C_x_PM_AON_BUF_X4%5_c4 VSS x_PM_AON_BUF_X4%5_22 6.9109e-17
C_x_PM_AON_BUF_X4%5_c5 VSS x_PM_AON_BUF_X4%5_19 4.616e-18
C_x_PM_AON_BUF_X4%5_c6 VSS N_5_M2_g 4.29393e-17
C_x_PM_AON_BUF_X4%5_c7 VSS N_5_M5_g 2.86905e-17
C_x_PM_AON_BUF_X4%5_c8 VSS x_PM_AON_BUF_X4%5_10 7.17649e-18
C_x_PM_AON_BUF_X4%5_c9 VSS x_PM_AON_BUF_X4%5_9 1.0806e-17
C_x_PM_AON_BUF_X4%5_c10 VSS N_5_M1_g 3.54147e-17
C_x_PM_AON_BUF_X4%5_c11 VSS N_5_M4_g 2.12137e-17
R_x_PM_AON_BUF_X4%5_r12 x_PM_AON_BUF_X4%5_39 x_PM_AON_BUF_X4%5_37 3.9
R_x_PM_AON_BUF_X4%5_r13 x_PM_AON_BUF_X4%5_37 x_PM_AON_BUF_X4%5_35 25.0012
R_x_PM_AON_BUF_X4%5_r14 x_PM_AON_BUF_X4%5_35 x_PM_AON_BUF_X4%5_33 0.990714
R_x_PM_AON_BUF_X4%5_r15 x_PM_AON_BUF_X4%5_35 x_PM_AON_BUF_X4%5_32 0.583571
R_x_PM_AON_BUF_X4%5_r16 x_PM_AON_BUF_X4%5_32 x_PM_AON_BUF_X4%5_30 0.212317
R_x_PM_AON_BUF_X4%5_r17 x_PM_AON_BUF_X4%5_31 x_PM_AON_BUF_X4%5_30 1.03143
R_x_PM_AON_BUF_X4%5_r18 x_PM_AON_BUF_X4%5_31 x_PM_AON_BUF_X4%5_26 0.212317
R_x_PM_AON_BUF_X4%5_r19 N_5_M3_s x_PM_AON_BUF_X4%5_26 0.447857
R_x_PM_AON_BUF_X4%5_r20 x_PM_AON_BUF_X4%5_33 x_PM_AON_BUF_X4%5_22 0.212317
R_x_PM_AON_BUF_X4%5_r21 N_5_M0_s x_PM_AON_BUF_X4%5_22 1.20786
R_x_PM_AON_BUF_X4%5_r22 x_PM_AON_BUF_X4%5_19 x_PM_AON_BUF_X4%5_15 4.56151
R_x_PM_AON_BUF_X4%5_r23 N_5_M2_g x_PM_AON_BUF_X4%5_15 43.68
R_x_PM_AON_BUF_X4%5_r24 x_PM_AON_BUF_X4%5_19 x_PM_AON_BUF_X4%5_11 4.56151
R_x_PM_AON_BUF_X4%5_r25 N_5_M5_g x_PM_AON_BUF_X4%5_11 28.86
R_x_PM_AON_BUF_X4%5_r26 x_PM_AON_BUF_X4%5_39 x_PM_AON_BUF_X4%5_10 2.6
R_x_PM_AON_BUF_X4%5_r27 x_PM_AON_BUF_X4%5_19 x_PM_AON_BUF_X4%5_9 0.043368
R_x_PM_AON_BUF_X4%5_r28 x_PM_AON_BUF_X4%5_10 x_PM_AON_BUF_X4%5_9 14.56
R_x_PM_AON_BUF_X4%5_r29 x_PM_AON_BUF_X4%5_39 x_PM_AON_BUF_X4%5_5 1.95
R_x_PM_AON_BUF_X4%5_r30 N_5_M1_g x_PM_AON_BUF_X4%5_5 43.68
R_x_PM_AON_BUF_X4%5_r31 x_PM_AON_BUF_X4%5_39 x_PM_AON_BUF_X4%5_1 1.95
R_x_PM_AON_BUF_X4%5_r32 N_5_M4_g x_PM_AON_BUF_X4%5_1 28.86
C_x_PM_AON_BUF_X4%Z_c0 VSS Z 5.94968e-17
C_x_PM_AON_BUF_X4%Z_c1 VSS N_Z_M1_d 5.91852e-17
C_x_PM_AON_BUF_X4%Z_c2 VSS x_PM_AON_BUF_X4%Z_4 4.64843e-17
R_x_PM_AON_BUF_X4%Z_r3 Z x_PM_AON_BUF_X4%Z_9 0.393571
R_x_PM_AON_BUF_X4%Z_r4 x_PM_AON_BUF_X4%Z_9 x_PM_AON_BUF_X4%Z_5 0.095
R_x_PM_AON_BUF_X4%Z_r5 N_Z_M1_d x_PM_AON_BUF_X4%Z_5 0.936429
R_x_PM_AON_BUF_X4%Z_r6 x_PM_AON_BUF_X4%Z_9 x_PM_AON_BUF_X4%Z_4 0.095
R_x_PM_AON_BUF_X4%Z_r7 x_PM_AON_BUF_X4%Z_4 N_Z_M4_d 0.570339
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AON_INV_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AON_INV_X1 VDD VSS VDDBAK A Z
*.PININFO VDD:P VSS:G VDDBAK:P A:I Z:O
*.EQN Z=!A
M_M1 N_Z_M0_d N_A_M0_g N_VDDBAK_M0_s VDD PMOS_VTL W=0.130000U L=0.050000U
M_M0 N_Z_M1_d N_A_M1_g N_VSS_M1_s VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_AON_INV_X1%VDD_c0 VSS x_PM_AON_INV_X1%VDD_27 9.30968e-17
C_x_PM_AON_INV_X1%VDD_c1 VSS x_PM_AON_INV_X1%VDD_24 1.07335e-17
C_x_PM_AON_INV_X1%VDD_c2 VSS x_PM_AON_INV_X1%VDD_23 2.334e-16
C_x_PM_AON_INV_X1%VDD_c3 VSS x_PM_AON_INV_X1%VDD_14 2.61714e-16
C_x_PM_AON_INV_X1%VDD_c4 VSS x_PM_AON_INV_X1%VDD_11 1.92462e-17
C_x_PM_AON_INV_X1%VDD_c5 VSS x_PM_AON_INV_X1%VDD_7 6.03662e-16
R_x_PM_AON_INV_X1%VDD_r6 x_PM_AON_INV_X1%VDD_27 x_PM_AON_INV_X1%VDD_25 0.13879
R_x_PM_AON_INV_X1%VDD_r7 x_PM_AON_INV_X1%VDD_24 x_PM_AON_INV_X1%VDD_27 2.74941
R_x_PM_AON_INV_X1%VDD_r8 x_PM_AON_INV_X1%VDD_24 x_PM_AON_INV_X1%VDD_25 0.138595
R_x_PM_AON_INV_X1%VDD_r9 x_PM_AON_INV_X1%VDD_23 x_PM_AON_INV_X1%VDD_25 0.138985
R_x_PM_AON_INV_X1%VDD_r10 x_PM_AON_INV_X1%VDD_14 x_PM_AON_INV_X1%VDD_25 0.13879
R_x_PM_AON_INV_X1%VDD_r11 VDD x_PM_AON_INV_X1%VDD_14 3.84471
R_x_PM_AON_INV_X1%VDD_r12 x_PM_AON_INV_X1%VDD_25 x_PM_AON_INV_X1%VDD_11 0.140282
R_x_PM_AON_INV_X1%VDD_r13 x_PM_AON_INV_X1%VDD_11 x_PM_AON_INV_X1%VDD_23 7.68941
R_x_PM_AON_INV_X1%VDD_r14 VDD x_PM_AON_INV_X1%VDD_7 9.36588
C_x_PM_AON_INV_X1%VSS_c0 VSS VSS 2.61611e-16
C_x_PM_AON_INV_X1%VSS_c1 VSS x_PM_AON_INV_X1%VSS_33 2.9494e-18
C_x_PM_AON_INV_X1%VSS_c2 VSS x_PM_AON_INV_X1%VSS_32 1.05694e-17
C_x_PM_AON_INV_X1%VSS_c3 VSS x_PM_AON_INV_X1%VSS_31 2.334e-16
C_x_PM_AON_INV_X1%VSS_c4 VSS x_PM_AON_INV_X1%VSS_19 5.53693e-17
C_x_PM_AON_INV_X1%VSS_c5 VSS N_VSS_M1_s 2.79675e-17
C_x_PM_AON_INV_X1%VSS_c6 VSS x_PM_AON_INV_X1%VSS_13 3.29135e-17
C_x_PM_AON_INV_X1%VSS_c7 VSS x_PM_AON_INV_X1%VSS_10 6.03662e-16
C_x_PM_AON_INV_X1%VSS_c8 VSS x_PM_AON_INV_X1%VSS_9 1.92462e-17
R_x_PM_AON_INV_X1%VSS_r9 x_PM_AON_INV_X1%VSS_32 VSS 0.138595
R_x_PM_AON_INV_X1%VSS_r10 x_PM_AON_INV_X1%VSS_31 VSS 0.138985
R_x_PM_AON_INV_X1%VSS_r11 x_PM_AON_INV_X1%VSS_33 x_PM_AON_INV_X1%VSS_20 0.073144
R_x_PM_AON_INV_X1%VSS_r12 VSS x_PM_AON_INV_X1%VSS_20 0.134118
R_x_PM_AON_INV_X1%VSS_r13 x_PM_AON_INV_X1%VSS_19 VSS 0.13879
R_x_PM_AON_INV_X1%VSS_r14 VSS x_PM_AON_INV_X1%VSS_19 1.37471
R_x_PM_AON_INV_X1%VSS_r15 x_PM_AON_INV_X1%VSS_33 x_PM_AON_INV_X1%VSS_15 0.145286
R_x_PM_AON_INV_X1%VSS_r16 N_VSS_M1_s x_PM_AON_INV_X1%VSS_15 0.800714
R_x_PM_AON_INV_X1%VSS_r17 x_PM_AON_INV_X1%VSS_33 x_PM_AON_INV_X1%VSS_13 0.073144
R_x_PM_AON_INV_X1%VSS_r18 x_PM_AON_INV_X1%VSS_32 x_PM_AON_INV_X1%VSS_13 1.08412
R_x_PM_AON_INV_X1%VSS_r19 VSS x_PM_AON_INV_X1%VSS_10 9.36588
R_x_PM_AON_INV_X1%VSS_r20 VSS x_PM_AON_INV_X1%VSS_9 0.140282
R_x_PM_AON_INV_X1%VSS_r21 x_PM_AON_INV_X1%VSS_9 x_PM_AON_INV_X1%VSS_31 7.68941
C_x_PM_AON_INV_X1%VDDBAK_c0 VSS VDD 3.47384e-17
C_x_PM_AON_INV_X1%VDDBAK_c1 VSS x_PM_AON_INV_X1%VDDBAK_9 1.54115e-17
C_x_PM_AON_INV_X1%VDDBAK_c2 VSS N_VDDBAK_M0_s 2.82576e-17
R_x_PM_AON_INV_X1%VDDBAK_r3 VDD VDDBAK 0.09975
R_x_PM_AON_INV_X1%VDDBAK_r4 VDDBAK x_PM_AON_INV_X1%VDDBAK_9 0.1615
R_x_PM_AON_INV_X1%VDDBAK_r5 x_PM_AON_INV_X1%VDDBAK_9 x_PM_AON_INV_X1%VDDBAK_5 0.283756
R_x_PM_AON_INV_X1%VDDBAK_r6 N_VDDBAK_M0_s x_PM_AON_INV_X1%VDDBAK_5 0.882143
C_x_PM_AON_INV_X1%A_c0 VSS x_PM_AON_INV_X1%A_18 1.07433e-17
C_x_PM_AON_INV_X1%A_c1 VSS x_PM_AON_INV_X1%A_12 4.09246e-17
C_x_PM_AON_INV_X1%A_c2 VSS N_A_M0_g 4.0526e-17
C_x_PM_AON_INV_X1%A_c3 VSS N_A_M1_g 4.02669e-17
R_x_PM_AON_INV_X1%A_r4 x_PM_AON_INV_X1%A_18 x_PM_AON_INV_X1%A_14 4.42
R_x_PM_AON_INV_X1%A_r5 x_PM_AON_INV_X1%A_14 x_PM_AON_INV_X1%A_12 25.0012
R_x_PM_AON_INV_X1%A_r6 x_PM_AON_INV_X1%A_12 A 0.1425
R_x_PM_AON_INV_X1%A_r7 x_PM_AON_INV_X1%A_18 x_PM_AON_INV_X1%A_5 1.95
R_x_PM_AON_INV_X1%A_r8 N_A_M0_g x_PM_AON_INV_X1%A_5 32.76
R_x_PM_AON_INV_X1%A_r9 x_PM_AON_INV_X1%A_18 x_PM_AON_INV_X1%A_1 1.95
R_x_PM_AON_INV_X1%A_r10 N_A_M1_g x_PM_AON_INV_X1%A_1 34.32
C_x_PM_AON_INV_X1%Z_c0 VSS N_Z_M1_d 9.51248e-17
R_x_PM_AON_INV_X1%Z_r1 N_Z_M0_d Z 1.28929
R_x_PM_AON_INV_X1%Z_r2 Z N_Z_M1_d 1.37071
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AON_INV_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AON_INV_X2 VDD VSS VDDBAK A Z
*.PININFO VDD:P VSS:G VDDBAK:P A:I Z:O
*.EQN Z=!A
M_M1 N_Z_M0_d N_A_M0_g N_VDDBAK_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_Z_M1_d N_A_M1_g N_VSS_M1_s VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AON_INV_X2%VDD_c0 VSS x_PM_AON_INV_X2%VDD_27 9.33631e-17
C_x_PM_AON_INV_X2%VDD_c1 VSS x_PM_AON_INV_X2%VDD_24 1.07335e-17
C_x_PM_AON_INV_X2%VDD_c2 VSS x_PM_AON_INV_X2%VDD_23 2.334e-16
C_x_PM_AON_INV_X2%VDD_c3 VSS x_PM_AON_INV_X2%VDD_14 2.61714e-16
C_x_PM_AON_INV_X2%VDD_c4 VSS x_PM_AON_INV_X2%VDD_11 1.92462e-17
C_x_PM_AON_INV_X2%VDD_c5 VSS x_PM_AON_INV_X2%VDD_7 6.03662e-16
R_x_PM_AON_INV_X2%VDD_r6 x_PM_AON_INV_X2%VDD_27 x_PM_AON_INV_X2%VDD_25 0.13879
R_x_PM_AON_INV_X2%VDD_r7 x_PM_AON_INV_X2%VDD_24 x_PM_AON_INV_X2%VDD_27 2.74941
R_x_PM_AON_INV_X2%VDD_r8 x_PM_AON_INV_X2%VDD_24 x_PM_AON_INV_X2%VDD_25 0.138595
R_x_PM_AON_INV_X2%VDD_r9 x_PM_AON_INV_X2%VDD_23 x_PM_AON_INV_X2%VDD_25 0.138985
R_x_PM_AON_INV_X2%VDD_r10 x_PM_AON_INV_X2%VDD_14 x_PM_AON_INV_X2%VDD_25 0.13879
R_x_PM_AON_INV_X2%VDD_r11 VDD x_PM_AON_INV_X2%VDD_14 3.84471
R_x_PM_AON_INV_X2%VDD_r12 x_PM_AON_INV_X2%VDD_25 x_PM_AON_INV_X2%VDD_11 0.140282
R_x_PM_AON_INV_X2%VDD_r13 x_PM_AON_INV_X2%VDD_11 x_PM_AON_INV_X2%VDD_23 7.68941
R_x_PM_AON_INV_X2%VDD_r14 VDD x_PM_AON_INV_X2%VDD_7 9.36588
C_x_PM_AON_INV_X2%VSS_c0 VSS VSS 2.61664e-16
C_x_PM_AON_INV_X2%VSS_c1 VSS x_PM_AON_INV_X2%VSS_29 2.70103e-17
C_x_PM_AON_INV_X2%VSS_c2 VSS x_PM_AON_INV_X2%VSS_28 1.06053e-17
C_x_PM_AON_INV_X2%VSS_c3 VSS x_PM_AON_INV_X2%VSS_27 2.334e-16
C_x_PM_AON_INV_X2%VSS_c4 VSS x_PM_AON_INV_X2%VSS_15 5.49962e-17
C_x_PM_AON_INV_X2%VSS_c5 VSS x_PM_AON_INV_X2%VSS_13 3.08663e-17
C_x_PM_AON_INV_X2%VSS_c6 VSS x_PM_AON_INV_X2%VSS_10 6.03662e-16
C_x_PM_AON_INV_X2%VSS_c7 VSS x_PM_AON_INV_X2%VSS_9 1.92462e-17
R_x_PM_AON_INV_X2%VSS_r8 N_VSS_M1_s x_PM_AON_INV_X2%VSS_29 0.401111
R_x_PM_AON_INV_X2%VSS_r9 x_PM_AON_INV_X2%VSS_28 VSS 0.138595
R_x_PM_AON_INV_X2%VSS_r10 x_PM_AON_INV_X2%VSS_27 VSS 0.138985
R_x_PM_AON_INV_X2%VSS_r11 x_PM_AON_INV_X2%VSS_29 x_PM_AON_INV_X2%VSS_16 0.095
R_x_PM_AON_INV_X2%VSS_r12 VSS x_PM_AON_INV_X2%VSS_16 0.055882
R_x_PM_AON_INV_X2%VSS_r13 x_PM_AON_INV_X2%VSS_15 VSS 0.13879
R_x_PM_AON_INV_X2%VSS_r14 VSS x_PM_AON_INV_X2%VSS_15 1.37471
R_x_PM_AON_INV_X2%VSS_r15 x_PM_AON_INV_X2%VSS_29 x_PM_AON_INV_X2%VSS_13 0.095
R_x_PM_AON_INV_X2%VSS_r16 x_PM_AON_INV_X2%VSS_28 x_PM_AON_INV_X2%VSS_13 1.01706
R_x_PM_AON_INV_X2%VSS_r17 VSS x_PM_AON_INV_X2%VSS_10 9.36588
R_x_PM_AON_INV_X2%VSS_r18 VSS x_PM_AON_INV_X2%VSS_9 0.140282
R_x_PM_AON_INV_X2%VSS_r19 x_PM_AON_INV_X2%VSS_9 x_PM_AON_INV_X2%VSS_27 7.68941
C_x_PM_AON_INV_X2%VDDBAK_c0 VSS VDD 3.40016e-17
C_x_PM_AON_INV_X2%VDDBAK_c1 VSS x_PM_AON_INV_X2%VDDBAK_9 1.67032e-17
C_x_PM_AON_INV_X2%VDDBAK_c2 VSS N_VDDBAK_M0_s 4.61604e-17
R_x_PM_AON_INV_X2%VDDBAK_r3 VDD VDDBAK 0.19475
R_x_PM_AON_INV_X2%VDDBAK_r4 VDDBAK x_PM_AON_INV_X2%VDDBAK_9 0.076
R_x_PM_AON_INV_X2%VDDBAK_r5 x_PM_AON_INV_X2%VDDBAK_9 x_PM_AON_INV_X2%VDDBAK_5 0.283756
R_x_PM_AON_INV_X2%VDDBAK_r6 N_VDDBAK_M0_s x_PM_AON_INV_X2%VDDBAK_5 0.882143
C_x_PM_AON_INV_X2%A_c0 VSS x_PM_AON_INV_X2%A_17 1.05694e-17
C_x_PM_AON_INV_X2%A_c1 VSS x_PM_AON_INV_X2%A_11 5.04783e-17
C_x_PM_AON_INV_X2%A_c2 VSS N_A_M0_g 5.86311e-17
C_x_PM_AON_INV_X2%A_c3 VSS x_PM_AON_INV_X2%A_1 3.15534e-17
R_x_PM_AON_INV_X2%A_r4 x_PM_AON_INV_X2%A_17 x_PM_AON_INV_X2%A_13 3.9
R_x_PM_AON_INV_X2%A_r5 x_PM_AON_INV_X2%A_13 x_PM_AON_INV_X2%A_11 25.0012
R_x_PM_AON_INV_X2%A_r6 x_PM_AON_INV_X2%A_11 A 0.145667
R_x_PM_AON_INV_X2%A_r7 x_PM_AON_INV_X2%A_17 x_PM_AON_INV_X2%A_4 1.95
R_x_PM_AON_INV_X2%A_r8 N_A_M0_g x_PM_AON_INV_X2%A_4 42.9
R_x_PM_AON_INV_X2%A_r9 x_PM_AON_INV_X2%A_17 x_PM_AON_INV_X2%A_1 1.95
R_x_PM_AON_INV_X2%A_r10 N_A_M1_g x_PM_AON_INV_X2%A_1 21.84
C_x_PM_AON_INV_X2%Z_c0 VSS N_Z_M1_d 9.97357e-17
R_x_PM_AON_INV_X2%Z_r1 N_Z_M0_d Z 1.235
R_x_PM_AON_INV_X2%Z_r2 Z N_Z_M1_d 1.39786
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AON_INV_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT AON_INV_X4 VDD VSS VDDBAK A Z
*.PININFO VDD:P VSS:G VDDBAK:P A:I Z:O
*.EQN Z=!A
M_M2 N_Z_M0_d N_A_M0_g N_VDDBAK_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M3 N_VDDBAK_M1_d N_A_M1_g N_Z_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_Z_M2_d N_A_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M3_d N_A_M3_g N_Z_M2_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AON_INV_X4%VDD_c0 VSS x_PM_AON_INV_X4%VDD_27 1.12516e-16
C_x_PM_AON_INV_X4%VDD_c1 VSS x_PM_AON_INV_X4%VDD_24 1.07528e-17
C_x_PM_AON_INV_X4%VDD_c2 VSS x_PM_AON_INV_X4%VDD_23 2.334e-16
C_x_PM_AON_INV_X4%VDD_c3 VSS x_PM_AON_INV_X4%VDD_14 2.61734e-16
C_x_PM_AON_INV_X4%VDD_c4 VSS x_PM_AON_INV_X4%VDD_11 1.92462e-17
C_x_PM_AON_INV_X4%VDD_c5 VSS x_PM_AON_INV_X4%VDD_7 6.16516e-16
R_x_PM_AON_INV_X4%VDD_r6 x_PM_AON_INV_X4%VDD_27 x_PM_AON_INV_X4%VDD_25 0.13879
R_x_PM_AON_INV_X4%VDD_r7 x_PM_AON_INV_X4%VDD_24 x_PM_AON_INV_X4%VDD_27 3.17412
R_x_PM_AON_INV_X4%VDD_r8 x_PM_AON_INV_X4%VDD_24 x_PM_AON_INV_X4%VDD_25 0.138595
R_x_PM_AON_INV_X4%VDD_r9 x_PM_AON_INV_X4%VDD_23 x_PM_AON_INV_X4%VDD_25 0.138985
R_x_PM_AON_INV_X4%VDD_r10 x_PM_AON_INV_X4%VDD_14 x_PM_AON_INV_X4%VDD_25 0.13879
R_x_PM_AON_INV_X4%VDD_r11 VDD x_PM_AON_INV_X4%VDD_14 3.84471
R_x_PM_AON_INV_X4%VDD_r12 x_PM_AON_INV_X4%VDD_25 x_PM_AON_INV_X4%VDD_11 0.140282
R_x_PM_AON_INV_X4%VDD_r13 x_PM_AON_INV_X4%VDD_11 x_PM_AON_INV_X4%VDD_23 7.68941
R_x_PM_AON_INV_X4%VDD_r14 VDD x_PM_AON_INV_X4%VDD_7 9.57824
C_x_PM_AON_INV_X4%VSS_c0 VSS x_PM_AON_INV_X4%VSS_41 2.75619e-18
C_x_PM_AON_INV_X4%VSS_c1 VSS x_PM_AON_INV_X4%VSS_40 2.75619e-18
C_x_PM_AON_INV_X4%VSS_c2 VSS x_PM_AON_INV_X4%VSS_38 2.334e-16
C_x_PM_AON_INV_X4%VSS_c3 VSS VSS 2.616e-16
C_x_PM_AON_INV_X4%VSS_c4 VSS x_PM_AON_INV_X4%VSS_28 3.29228e-17
C_x_PM_AON_INV_X4%VSS_c5 VSS N_VSS_M3_d 1.18684e-17
C_x_PM_AON_INV_X4%VSS_c6 VSS x_PM_AON_INV_X4%VSS_20 3.70749e-17
C_x_PM_AON_INV_X4%VSS_c7 VSS N_VSS_M2_s 2.25821e-17
C_x_PM_AON_INV_X4%VSS_c8 VSS x_PM_AON_INV_X4%VSS_15 1.06177e-17
C_x_PM_AON_INV_X4%VSS_c9 VSS x_PM_AON_INV_X4%VSS_14 3.25812e-17
C_x_PM_AON_INV_X4%VSS_c10 VSS x_PM_AON_INV_X4%VSS_11 6.16516e-16
C_x_PM_AON_INV_X4%VSS_c11 VSS x_PM_AON_INV_X4%VSS_10 1.92462e-17
R_x_PM_AON_INV_X4%VSS_r12 x_PM_AON_INV_X4%VSS_38 VSS 0.138985
R_x_PM_AON_INV_X4%VSS_r13 x_PM_AON_INV_X4%VSS_41 x_PM_AON_INV_X4%VSS_29 0.073144
R_x_PM_AON_INV_X4%VSS_r14 x_PM_AON_INV_X4%VSS_28 VSS 0.13879
R_x_PM_AON_INV_X4%VSS_r15 x_PM_AON_INV_X4%VSS_29 x_PM_AON_INV_X4%VSS_28 1.08412
R_x_PM_AON_INV_X4%VSS_r16 x_PM_AON_INV_X4%VSS_41 x_PM_AON_INV_X4%VSS_24 0.145286
R_x_PM_AON_INV_X4%VSS_r17 N_VSS_M3_d x_PM_AON_INV_X4%VSS_24 0.312143
R_x_PM_AON_INV_X4%VSS_r18 x_PM_AON_INV_X4%VSS_40 x_PM_AON_INV_X4%VSS_21 0.073144
R_x_PM_AON_INV_X4%VSS_r19 VSS x_PM_AON_INV_X4%VSS_21 0.357647
R_x_PM_AON_INV_X4%VSS_r20 x_PM_AON_INV_X4%VSS_41 x_PM_AON_INV_X4%VSS_20 0.073144
R_x_PM_AON_INV_X4%VSS_r21 VSS x_PM_AON_INV_X4%VSS_20 0.346471
R_x_PM_AON_INV_X4%VSS_r22 x_PM_AON_INV_X4%VSS_40 x_PM_AON_INV_X4%VSS_16 0.145286
R_x_PM_AON_INV_X4%VSS_r23 N_VSS_M2_s x_PM_AON_INV_X4%VSS_16 0.312143
R_x_PM_AON_INV_X4%VSS_r24 x_PM_AON_INV_X4%VSS_15 VSS 0.138595
R_x_PM_AON_INV_X4%VSS_r25 x_PM_AON_INV_X4%VSS_40 x_PM_AON_INV_X4%VSS_14 0.073144
R_x_PM_AON_INV_X4%VSS_r26 x_PM_AON_INV_X4%VSS_15 x_PM_AON_INV_X4%VSS_14 1.07294
R_x_PM_AON_INV_X4%VSS_r27 VSS x_PM_AON_INV_X4%VSS_11 9.57824
R_x_PM_AON_INV_X4%VSS_r28 VSS x_PM_AON_INV_X4%VSS_10 0.140282
R_x_PM_AON_INV_X4%VSS_r29 x_PM_AON_INV_X4%VSS_10 x_PM_AON_INV_X4%VSS_38 7.68941
C_x_PM_AON_INV_X4%VDDBAK_c0 VSS N_VDDBAK_M1_d 3.49098e-17
C_x_PM_AON_INV_X4%VDDBAK_c1 VSS x_PM_AON_INV_X4%VDDBAK_11 1.73546e-17
C_x_PM_AON_INV_X4%VDDBAK_c2 VSS x_PM_AON_INV_X4%VDDBAK_10 5.42942e-17
C_x_PM_AON_INV_X4%VDDBAK_c3 VSS N_VDDBAK_M0_s 3.83852e-17
R_x_PM_AON_INV_X4%VDDBAK_r4 N_VDDBAK_M1_d x_PM_AON_INV_X4%VDDBAK_17 0.800714
R_x_PM_AON_INV_X4%VDDBAK_r5 VDD VDDBAK 0.16625
R_x_PM_AON_INV_X4%VDDBAK_r6 VDDBAK x_PM_AON_INV_X4%VDDBAK_11 0.2755
R_x_PM_AON_INV_X4%VDDBAK_r7 x_PM_AON_INV_X4%VDDBAK_17 x_PM_AON_INV_X4%VDDBAK_10 0.283756
R_x_PM_AON_INV_X4%VDDBAK_r8 VDD x_PM_AON_INV_X4%VDDBAK_10 0.15675
R_x_PM_AON_INV_X4%VDDBAK_r9 x_PM_AON_INV_X4%VDDBAK_11 x_PM_AON_INV_X4%VDDBAK_6 0.283756
R_x_PM_AON_INV_X4%VDDBAK_r10 N_VDDBAK_M0_s x_PM_AON_INV_X4%VDDBAK_6 0.800714
C_x_PM_AON_INV_X4%A_c0 VSS x_PM_AON_INV_X4%A_21 5.29189e-17
C_x_PM_AON_INV_X4%A_c1 VSS x_PM_AON_INV_X4%A_17 3.30952e-18
C_x_PM_AON_INV_X4%A_c2 VSS N_A_M1_g 3.86365e-17
C_x_PM_AON_INV_X4%A_c3 VSS x_PM_AON_INV_X4%A_10 2.46953e-17
C_x_PM_AON_INV_X4%A_c4 VSS x_PM_AON_INV_X4%A_9 4.72784e-18
C_x_PM_AON_INV_X4%A_c5 VSS x_PM_AON_INV_X4%A_8 1.30018e-17
C_x_PM_AON_INV_X4%A_c6 VSS N_A_M0_g 3.81672e-17
C_x_PM_AON_INV_X4%A_c7 VSS x_PM_AON_INV_X4%A_1 2.39008e-17
R_x_PM_AON_INV_X4%A_r8 x_PM_AON_INV_X4%A_27 x_PM_AON_INV_X4%A_23 3.38
R_x_PM_AON_INV_X4%A_r9 x_PM_AON_INV_X4%A_23 x_PM_AON_INV_X4%A_21 25.0012
R_x_PM_AON_INV_X4%A_r10 x_PM_AON_INV_X4%A_21 A 0.140968
R_x_PM_AON_INV_X4%A_r11 x_PM_AON_INV_X4%A_17 x_PM_AON_INV_X4%A_13 4.56151
R_x_PM_AON_INV_X4%A_r12 N_A_M1_g x_PM_AON_INV_X4%A_13 42.12
R_x_PM_AON_INV_X4%A_r13 x_PM_AON_INV_X4%A_17 x_PM_AON_INV_X4%A_10 4.56151
R_x_PM_AON_INV_X4%A_r14 N_A_M3_g x_PM_AON_INV_X4%A_10 21.84
R_x_PM_AON_INV_X4%A_r15 x_PM_AON_INV_X4%A_27 x_PM_AON_INV_X4%A_9 2.6
R_x_PM_AON_INV_X4%A_r16 x_PM_AON_INV_X4%A_17 x_PM_AON_INV_X4%A_8 0.043368
R_x_PM_AON_INV_X4%A_r17 x_PM_AON_INV_X4%A_9 x_PM_AON_INV_X4%A_8 15.08
R_x_PM_AON_INV_X4%A_r18 x_PM_AON_INV_X4%A_27 x_PM_AON_INV_X4%A_4 1.95
R_x_PM_AON_INV_X4%A_r19 N_A_M0_g x_PM_AON_INV_X4%A_4 42.12
R_x_PM_AON_INV_X4%A_r20 x_PM_AON_INV_X4%A_27 x_PM_AON_INV_X4%A_1 1.95
R_x_PM_AON_INV_X4%A_r21 N_A_M2_g x_PM_AON_INV_X4%A_1 21.84
C_x_PM_AON_INV_X4%Z_c0 VSS N_Z_M2_d 1.27953e-16
R_x_PM_AON_INV_X4%Z_r1 N_Z_M0_d Z 1.26214
R_x_PM_AON_INV_X4%Z_r2 Z N_Z_M2_d 1.39786
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HEADER_OE_X1.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HEADER_OE_X1 VDD VSS SLEEP VVDD SLEEPOUT
*.PININFO VDD:P VSS:G SLEEP:I VVDD:P SLEEPOUT:O
*.EQN SLEEPOUT=SLEEP
M_M2 N_VVDD_M0_d N_SLEEP_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_VDD_M1_d N_SLEEP_M1_g N_5_M1_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_SLEEPOUT_M2_d N_5_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M3_d N_SLEEP_M3_g N_5_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_SLEEPOUT_M4_d N_5_M4_g N_VSS_M3_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_HEADER_OE_X1%VDD_c0 VSS x_PM_HEADER_OE_X1%VDD_37 2.06322e-17
C_x_PM_HEADER_OE_X1%VDD_c1 VSS x_PM_HEADER_OE_X1%VDD_34 5.76125e-18
C_x_PM_HEADER_OE_X1%VDD_c2 VSS x_PM_HEADER_OE_X1%VDD_33 1.74022e-17
C_x_PM_HEADER_OE_X1%VDD_c3 VSS x_PM_HEADER_OE_X1%VDD_24 2.61461e-16
C_x_PM_HEADER_OE_X1%VDD_c4 VSS N_VDD_M1_d 5.61896e-17
C_x_PM_HEADER_OE_X1%VDD_c5 VSS x_PM_HEADER_OE_X1%VDD_17 1.94187e-17
C_x_PM_HEADER_OE_X1%VDD_c6 VSS x_PM_HEADER_OE_X1%VDD_16 3.57523e-17
C_x_PM_HEADER_OE_X1%VDD_c7 VSS x_PM_HEADER_OE_X1%VDD_13 1.92462e-17
C_x_PM_HEADER_OE_X1%VDD_c8 VSS x_PM_HEADER_OE_X1%VDD_12 2.334e-16
C_x_PM_HEADER_OE_X1%VDD_c9 VSS x_PM_HEADER_OE_X1%VDD_9 5.90809e-16
R_x_PM_HEADER_OE_X1%VDD_r10 x_PM_HEADER_OE_X1%VDD_37 VDD 0.13879
R_x_PM_HEADER_OE_X1%VDD_r11 x_PM_HEADER_OE_X1%VDD_33 VDD 0.403043
R_x_PM_HEADER_OE_X1%VDD_r12 x_PM_HEADER_OE_X1%VDD_24 VDD 0.13879
R_x_PM_HEADER_OE_X1%VDD_r13 VDD x_PM_HEADER_OE_X1%VDD_24 3.84471
R_x_PM_HEADER_OE_X1%VDD_r14 x_PM_HEADER_OE_X1%VDD_34 x_PM_HEADER_OE_X1%VDD_23 0.132285
R_x_PM_HEADER_OE_X1%VDD_r15 x_PM_HEADER_OE_X1%VDD_23 x_PM_HEADER_OE_X1%VDD_37 0.625882
R_x_PM_HEADER_OE_X1%VDD_r16 x_PM_HEADER_OE_X1%VDD_34 x_PM_HEADER_OE_X1%VDD_18 0.068038
R_x_PM_HEADER_OE_X1%VDD_r17 N_VDD_M1_d x_PM_HEADER_OE_X1%VDD_18 0.823333
R_x_PM_HEADER_OE_X1%VDD_r18 x_PM_HEADER_OE_X1%VDD_33 x_PM_HEADER_OE_X1%VDD_17 0.075321
R_x_PM_HEADER_OE_X1%VDD_r19 x_PM_HEADER_OE_X1%VDD_34 x_PM_HEADER_OE_X1%VDD_16 0.132285
R_x_PM_HEADER_OE_X1%VDD_r20 x_PM_HEADER_OE_X1%VDD_17 x_PM_HEADER_OE_X1%VDD_16 1.03941
R_x_PM_HEADER_OE_X1%VDD_r21 x_PM_HEADER_OE_X1%VDD_33 N_VDD_M0_s 0.543196
R_x_PM_HEADER_OE_X1%VDD_r22 VDD x_PM_HEADER_OE_X1%VDD_13 0.140282
R_x_PM_HEADER_OE_X1%VDD_r23 VDD x_PM_HEADER_OE_X1%VDD_12 0.143612
R_x_PM_HEADER_OE_X1%VDD_r24 x_PM_HEADER_OE_X1%VDD_13 x_PM_HEADER_OE_X1%VDD_12 7.68941
R_x_PM_HEADER_OE_X1%VDD_r25 VDD x_PM_HEADER_OE_X1%VDD_9 9.15353
C_x_PM_HEADER_OE_X1%VSS_c0 VSS x_PM_HEADER_OE_X1%VSS_34 2.69945e-17
C_x_PM_HEADER_OE_X1%VSS_c1 VSS x_PM_HEADER_OE_X1%VSS_31 5.66099e-18
C_x_PM_HEADER_OE_X1%VSS_c2 VSS x_PM_HEADER_OE_X1%VSS_29 2.334e-16
C_x_PM_HEADER_OE_X1%VSS_c3 VSS VSS 2.61461e-16
C_x_PM_HEADER_OE_X1%VSS_c4 VSS x_PM_HEADER_OE_X1%VSS_18 4.37651e-17
C_x_PM_HEADER_OE_X1%VSS_c5 VSS x_PM_HEADER_OE_X1%VSS_14 1.0616e-17
C_x_PM_HEADER_OE_X1%VSS_c6 VSS x_PM_HEADER_OE_X1%VSS_13 5.18983e-17
C_x_PM_HEADER_OE_X1%VSS_c7 VSS x_PM_HEADER_OE_X1%VSS_10 5.90809e-16
C_x_PM_HEADER_OE_X1%VSS_c8 VSS x_PM_HEADER_OE_X1%VSS_9 1.92462e-17
R_x_PM_HEADER_OE_X1%VSS_r9 x_PM_HEADER_OE_X1%VSS_34 VSS 0.13879
R_x_PM_HEADER_OE_X1%VSS_r10 x_PM_HEADER_OE_X1%VSS_29 VSS 0.138985
R_x_PM_HEADER_OE_X1%VSS_r11 x_PM_HEADER_OE_X1%VSS_31 x_PM_HEADER_OE_X1%VSS_20 0.132285
R_x_PM_HEADER_OE_X1%VSS_r12 x_PM_HEADER_OE_X1%VSS_20 x_PM_HEADER_OE_X1%VSS_34 0.625882
R_x_PM_HEADER_OE_X1%VSS_r13 x_PM_HEADER_OE_X1%VSS_31 x_PM_HEADER_OE_X1%VSS_18 0.068038
R_x_PM_HEADER_OE_X1%VSS_r14 x_PM_HEADER_OE_X1%VSS_18 N_VSS_M3_d 0.347287
R_x_PM_HEADER_OE_X1%VSS_r15 x_PM_HEADER_OE_X1%VSS_14 VSS 0.138595
R_x_PM_HEADER_OE_X1%VSS_r16 VSS x_PM_HEADER_OE_X1%VSS_14 1.16235
R_x_PM_HEADER_OE_X1%VSS_r17 x_PM_HEADER_OE_X1%VSS_31 x_PM_HEADER_OE_X1%VSS_13 0.132285
R_x_PM_HEADER_OE_X1%VSS_r18 VSS x_PM_HEADER_OE_X1%VSS_13 0.234706
R_x_PM_HEADER_OE_X1%VSS_r19 VSS x_PM_HEADER_OE_X1%VSS_10 9.15353
R_x_PM_HEADER_OE_X1%VSS_r20 VSS x_PM_HEADER_OE_X1%VSS_9 0.140282
R_x_PM_HEADER_OE_X1%VSS_r21 x_PM_HEADER_OE_X1%VSS_9 x_PM_HEADER_OE_X1%VSS_29 7.68941
C_x_PM_HEADER_OE_X1%SLEEP_c0 VSS x_PM_HEADER_OE_X1%SLEEP_21 6.92558e-18
C_x_PM_HEADER_OE_X1%SLEEP_c1 VSS x_PM_HEADER_OE_X1%SLEEP_19 6.32861e-17
C_x_PM_HEADER_OE_X1%SLEEP_c2 VSS x_PM_HEADER_OE_X1%SLEEP_15 7.40284e-18
C_x_PM_HEADER_OE_X1%SLEEP_c3 VSS N_SLEEP_M1_g 4.78936e-17
C_x_PM_HEADER_OE_X1%SLEEP_c4 VSS N_SLEEP_M3_g 5.05196e-17
C_x_PM_HEADER_OE_X1%SLEEP_c5 VSS N_SLEEP_M0_g 6.36345e-17
R_x_PM_HEADER_OE_X1%SLEEP_r6 x_PM_HEADER_OE_X1%SLEEP_28 x_PM_HEADER_OE_X1%SLEEP_21 4.7687
R_x_PM_HEADER_OE_X1%SLEEP_r7 x_PM_HEADER_OE_X1%SLEEP_27 x_PM_HEADER_OE_X1%SLEEP_21 4.7687
R_x_PM_HEADER_OE_X1%SLEEP_r8 x_PM_HEADER_OE_X1%SLEEP_21 x_PM_HEADER_OE_X1%SLEEP_19 25.0012
R_x_PM_HEADER_OE_X1%SLEEP_r9 x_PM_HEADER_OE_X1%SLEEP_19 SLEEP 0.698929
R_x_PM_HEADER_OE_X1%SLEEP_r10 x_PM_HEADER_OE_X1%SLEEP_25 x_PM_HEADER_OE_X1%SLEEP_15 4.7687
R_x_PM_HEADER_OE_X1%SLEEP_r11 x_PM_HEADER_OE_X1%SLEEP_15 x_PM_HEADER_OE_X1%SLEEP_13 25.0012
R_x_PM_HEADER_OE_X1%SLEEP_r12 SLEEP x_PM_HEADER_OE_X1%SLEEP_13 0.278214
R_x_PM_HEADER_OE_X1%SLEEP_r13 N_SLEEP_M1_g x_PM_HEADER_OE_X1%SLEEP_28 51.09
R_x_PM_HEADER_OE_X1%SLEEP_r14 N_SLEEP_M3_g x_PM_HEADER_OE_X1%SLEEP_27 54.6
R_x_PM_HEADER_OE_X1%SLEEP_r15 N_SLEEP_M0_g x_PM_HEADER_OE_X1%SLEEP_25 76.05
C_x_PM_HEADER_OE_X1%VVDD_c0 VSS VVDD 6.81157e-17
R_x_PM_HEADER_OE_X1%VVDD_r1 N_VVDD_M0_d VVDD 0.306111
C_x_PM_HEADER_OE_X1%5_c0 VSS x_PM_HEADER_OE_X1%5_28 1.10507e-17
C_x_PM_HEADER_OE_X1%5_c1 VSS x_PM_HEADER_OE_X1%5_24 9.36208e-17
C_x_PM_HEADER_OE_X1%5_c2 VSS x_PM_HEADER_OE_X1%5_20 1.44382e-17
C_x_PM_HEADER_OE_X1%5_c3 VSS x_PM_HEADER_OE_X1%5_19 4.66831e-17
C_x_PM_HEADER_OE_X1%5_c4 VSS x_PM_HEADER_OE_X1%5_18 1.00234e-17
C_x_PM_HEADER_OE_X1%5_c5 VSS x_PM_HEADER_OE_X1%5_17 4.34966e-17
C_x_PM_HEADER_OE_X1%5_c6 VSS N_5_M1_s 2.34195e-17
C_x_PM_HEADER_OE_X1%5_c7 VSS x_PM_HEADER_OE_X1%5_12 3.03699e-17
C_x_PM_HEADER_OE_X1%5_c8 VSS N_5_M2_g 6.31097e-17
C_x_PM_HEADER_OE_X1%5_c9 VSS N_5_M4_g 3.57054e-17
R_x_PM_HEADER_OE_X1%5_r10 x_PM_HEADER_OE_X1%5_28 x_PM_HEADER_OE_X1%5_26 2.86
R_x_PM_HEADER_OE_X1%5_r11 x_PM_HEADER_OE_X1%5_26 x_PM_HEADER_OE_X1%5_24 25.0012
R_x_PM_HEADER_OE_X1%5_r12 x_PM_HEADER_OE_X1%5_24 x_PM_HEADER_OE_X1%5_22 1.91357
R_x_PM_HEADER_OE_X1%5_r13 x_PM_HEADER_OE_X1%5_24 x_PM_HEADER_OE_X1%5_21 0.176429
R_x_PM_HEADER_OE_X1%5_r14 x_PM_HEADER_OE_X1%5_22 x_PM_HEADER_OE_X1%5_19 0.212317
R_x_PM_HEADER_OE_X1%5_r15 x_PM_HEADER_OE_X1%5_20 x_PM_HEADER_OE_X1%5_19 1.00429
R_x_PM_HEADER_OE_X1%5_r16 x_PM_HEADER_OE_X1%5_21 x_PM_HEADER_OE_X1%5_17 0.212317
R_x_PM_HEADER_OE_X1%5_r17 x_PM_HEADER_OE_X1%5_18 x_PM_HEADER_OE_X1%5_17 1.00429
R_x_PM_HEADER_OE_X1%5_r18 x_PM_HEADER_OE_X1%5_20 x_PM_HEADER_OE_X1%5_13 0.212317
R_x_PM_HEADER_OE_X1%5_r19 N_5_M1_s x_PM_HEADER_OE_X1%5_13 0.312143
R_x_PM_HEADER_OE_X1%5_r20 x_PM_HEADER_OE_X1%5_18 x_PM_HEADER_OE_X1%5_12 0.212317
R_x_PM_HEADER_OE_X1%5_r21 x_PM_HEADER_OE_X1%5_12 N_5_M3_s 0.543196
R_x_PM_HEADER_OE_X1%5_r22 x_PM_HEADER_OE_X1%5_28 x_PM_HEADER_OE_X1%5_5 1.95
R_x_PM_HEADER_OE_X1%5_r23 N_5_M2_g x_PM_HEADER_OE_X1%5_5 73.71
R_x_PM_HEADER_OE_X1%5_r24 x_PM_HEADER_OE_X1%5_28 x_PM_HEADER_OE_X1%5_1 1.95
R_x_PM_HEADER_OE_X1%5_r25 N_5_M4_g x_PM_HEADER_OE_X1%5_1 31.98
C_x_PM_HEADER_OE_X1%SLEEPOUT_c0 VSS N_SLEEPOUT_M4_d 1.39056e-16
R_x_PM_HEADER_OE_X1%SLEEPOUT_r1 N_SLEEPOUT_M2_d SLEEPOUT 1.805
R_x_PM_HEADER_OE_X1%SLEEPOUT_r2 SLEEPOUT N_SLEEPOUT_M4_d 2.07643
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HEADER_OE_X2.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HEADER_OE_X2 VDD VSS SLEEP VVDD SLEEPOUT
*.PININFO VDD:P VSS:G SLEEP:I VVDD:P SLEEPOUT:O
*.EQN SLEEPOUT=SLEEP
M_M2 N_VVDD_M0_d N_SLEEP_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M3 N_VDD_M1_d N_SLEEP_M1_g N_5_M1_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_SLEEPOUT_M2_d N_5_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M3_d N_SLEEP_M3_g N_5_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_SLEEPOUT_M4_d N_5_M4_g N_VSS_M3_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_HEADER_OE_X2%VDD_c0 VSS x_PM_HEADER_OE_X2%VDD_39 2.89096e-17
C_x_PM_HEADER_OE_X2%VDD_c1 VSS x_PM_HEADER_OE_X2%VDD_36 2.9494e-18
C_x_PM_HEADER_OE_X2%VDD_c2 VSS x_PM_HEADER_OE_X2%VDD_26 2.61486e-16
C_x_PM_HEADER_OE_X2%VDD_c3 VSS N_VDD_M1_d 2.76224e-17
C_x_PM_HEADER_OE_X2%VDD_c4 VSS x_PM_HEADER_OE_X2%VDD_19 1.91289e-17
C_x_PM_HEADER_OE_X2%VDD_c5 VSS x_PM_HEADER_OE_X2%VDD_18 3.95665e-17
C_x_PM_HEADER_OE_X2%VDD_c6 VSS N_VDD_M0_s 3.40724e-17
C_x_PM_HEADER_OE_X2%VDD_c7 VSS x_PM_HEADER_OE_X2%VDD_13 1.92462e-17
C_x_PM_HEADER_OE_X2%VDD_c8 VSS x_PM_HEADER_OE_X2%VDD_12 2.334e-16
C_x_PM_HEADER_OE_X2%VDD_c9 VSS x_PM_HEADER_OE_X2%VDD_9 5.90809e-16
R_x_PM_HEADER_OE_X2%VDD_r10 x_PM_HEADER_OE_X2%VDD_39 VDD 0.13879
R_x_PM_HEADER_OE_X2%VDD_r11 x_PM_HEADER_OE_X2%VDD_35 VDD 0.392137
R_x_PM_HEADER_OE_X2%VDD_r12 x_PM_HEADER_OE_X2%VDD_26 VDD 0.13879
R_x_PM_HEADER_OE_X2%VDD_r13 VDD x_PM_HEADER_OE_X2%VDD_26 3.84471
R_x_PM_HEADER_OE_X2%VDD_r14 x_PM_HEADER_OE_X2%VDD_36 x_PM_HEADER_OE_X2%VDD_25 0.073144
R_x_PM_HEADER_OE_X2%VDD_r15 x_PM_HEADER_OE_X2%VDD_25 x_PM_HEADER_OE_X2%VDD_39 0.737647
R_x_PM_HEADER_OE_X2%VDD_r16 x_PM_HEADER_OE_X2%VDD_36 x_PM_HEADER_OE_X2%VDD_20 0.145286
R_x_PM_HEADER_OE_X2%VDD_r17 N_VDD_M1_d x_PM_HEADER_OE_X2%VDD_20 0.800714
R_x_PM_HEADER_OE_X2%VDD_r18 x_PM_HEADER_OE_X2%VDD_35 x_PM_HEADER_OE_X2%VDD_19 0.0753
R_x_PM_HEADER_OE_X2%VDD_r19 x_PM_HEADER_OE_X2%VDD_36 x_PM_HEADER_OE_X2%VDD_18 0.073144
R_x_PM_HEADER_OE_X2%VDD_r20 x_PM_HEADER_OE_X2%VDD_19 x_PM_HEADER_OE_X2%VDD_18 1.08412
R_x_PM_HEADER_OE_X2%VDD_r21 N_VDD_M0_s x_PM_HEADER_OE_X2%VDD_35 0.800714
R_x_PM_HEADER_OE_X2%VDD_r22 VDD x_PM_HEADER_OE_X2%VDD_13 0.140282
R_x_PM_HEADER_OE_X2%VDD_r23 VDD x_PM_HEADER_OE_X2%VDD_12 0.143516
R_x_PM_HEADER_OE_X2%VDD_r24 x_PM_HEADER_OE_X2%VDD_13 x_PM_HEADER_OE_X2%VDD_12 7.68941
R_x_PM_HEADER_OE_X2%VDD_r25 VDD x_PM_HEADER_OE_X2%VDD_9 9.15353
C_x_PM_HEADER_OE_X2%VSS_c0 VSS x_PM_HEADER_OE_X2%VSS_34 3.83558e-17
C_x_PM_HEADER_OE_X2%VSS_c1 VSS x_PM_HEADER_OE_X2%VSS_31 2.7699e-18
C_x_PM_HEADER_OE_X2%VSS_c2 VSS x_PM_HEADER_OE_X2%VSS_29 2.334e-16
C_x_PM_HEADER_OE_X2%VSS_c3 VSS VSS 2.61603e-16
C_x_PM_HEADER_OE_X2%VSS_c4 VSS x_PM_HEADER_OE_X2%VSS_18 4.24429e-17
C_x_PM_HEADER_OE_X2%VSS_c5 VSS x_PM_HEADER_OE_X2%VSS_14 1.06621e-17
C_x_PM_HEADER_OE_X2%VSS_c6 VSS x_PM_HEADER_OE_X2%VSS_13 5.5647e-17
C_x_PM_HEADER_OE_X2%VSS_c7 VSS x_PM_HEADER_OE_X2%VSS_10 5.90809e-16
C_x_PM_HEADER_OE_X2%VSS_c8 VSS x_PM_HEADER_OE_X2%VSS_9 1.92462e-17
R_x_PM_HEADER_OE_X2%VSS_r9 x_PM_HEADER_OE_X2%VSS_34 VSS 0.13879
R_x_PM_HEADER_OE_X2%VSS_r10 x_PM_HEADER_OE_X2%VSS_29 VSS 0.138985
R_x_PM_HEADER_OE_X2%VSS_r11 x_PM_HEADER_OE_X2%VSS_31 x_PM_HEADER_OE_X2%VSS_20 0.073144
R_x_PM_HEADER_OE_X2%VSS_r12 x_PM_HEADER_OE_X2%VSS_20 x_PM_HEADER_OE_X2%VSS_34 0.737647
R_x_PM_HEADER_OE_X2%VSS_r13 x_PM_HEADER_OE_X2%VSS_31 x_PM_HEADER_OE_X2%VSS_18 0.145286
R_x_PM_HEADER_OE_X2%VSS_r14 x_PM_HEADER_OE_X2%VSS_18 N_VSS_M3_d 0.543196
R_x_PM_HEADER_OE_X2%VSS_r15 x_PM_HEADER_OE_X2%VSS_14 VSS 0.138595
R_x_PM_HEADER_OE_X2%VSS_r16 VSS x_PM_HEADER_OE_X2%VSS_14 1.16235
R_x_PM_HEADER_OE_X2%VSS_r17 x_PM_HEADER_OE_X2%VSS_31 x_PM_HEADER_OE_X2%VSS_13 0.073144
R_x_PM_HEADER_OE_X2%VSS_r18 VSS x_PM_HEADER_OE_X2%VSS_13 0.268235
R_x_PM_HEADER_OE_X2%VSS_r19 VSS x_PM_HEADER_OE_X2%VSS_10 9.15353
R_x_PM_HEADER_OE_X2%VSS_r20 VSS x_PM_HEADER_OE_X2%VSS_9 0.140282
R_x_PM_HEADER_OE_X2%VSS_r21 x_PM_HEADER_OE_X2%VSS_9 x_PM_HEADER_OE_X2%VSS_29 7.68941
C_x_PM_HEADER_OE_X2%SLEEP_c0 VSS x_PM_HEADER_OE_X2%SLEEP_21 6.89492e-18
C_x_PM_HEADER_OE_X2%SLEEP_c1 VSS x_PM_HEADER_OE_X2%SLEEP_19 5.88298e-17
C_x_PM_HEADER_OE_X2%SLEEP_c2 VSS x_PM_HEADER_OE_X2%SLEEP_15 7.42747e-18
C_x_PM_HEADER_OE_X2%SLEEP_c3 VSS N_SLEEP_M1_g 6.59409e-17
C_x_PM_HEADER_OE_X2%SLEEP_c4 VSS N_SLEEP_M3_g 5.24623e-17
C_x_PM_HEADER_OE_X2%SLEEP_c5 VSS N_SLEEP_M0_g 6.65668e-17
R_x_PM_HEADER_OE_X2%SLEEP_r6 x_PM_HEADER_OE_X2%SLEEP_28 x_PM_HEADER_OE_X2%SLEEP_21 4.7687
R_x_PM_HEADER_OE_X2%SLEEP_r7 x_PM_HEADER_OE_X2%SLEEP_27 x_PM_HEADER_OE_X2%SLEEP_21 4.7687
R_x_PM_HEADER_OE_X2%SLEEP_r8 x_PM_HEADER_OE_X2%SLEEP_21 x_PM_HEADER_OE_X2%SLEEP_19 25.0012
R_x_PM_HEADER_OE_X2%SLEEP_r9 x_PM_HEADER_OE_X2%SLEEP_19 SLEEP 0.644643
R_x_PM_HEADER_OE_X2%SLEEP_r10 x_PM_HEADER_OE_X2%SLEEP_25 x_PM_HEADER_OE_X2%SLEEP_15 4.7687
R_x_PM_HEADER_OE_X2%SLEEP_r11 x_PM_HEADER_OE_X2%SLEEP_15 x_PM_HEADER_OE_X2%SLEEP_13 25.0012
R_x_PM_HEADER_OE_X2%SLEEP_r12 SLEEP x_PM_HEADER_OE_X2%SLEEP_13 0.278214
R_x_PM_HEADER_OE_X2%SLEEP_r13 N_SLEEP_M1_g x_PM_HEADER_OE_X2%SLEEP_28 73.71
R_x_PM_HEADER_OE_X2%SLEEP_r14 N_SLEEP_M3_g x_PM_HEADER_OE_X2%SLEEP_27 56.94
R_x_PM_HEADER_OE_X2%SLEEP_r15 N_SLEEP_M0_g x_PM_HEADER_OE_X2%SLEEP_25 63.18
C_x_PM_HEADER_OE_X2%VVDD_c0 VSS VVDD 8.47731e-17
R_x_PM_HEADER_OE_X2%VVDD_r1 N_VVDD_M0_d VVDD 0.855
C_x_PM_HEADER_OE_X2%5_c0 VSS x_PM_HEADER_OE_X2%5_30 1.14952e-17
C_x_PM_HEADER_OE_X2%5_c1 VSS x_PM_HEADER_OE_X2%5_26 9.97262e-17
C_x_PM_HEADER_OE_X2%5_c2 VSS x_PM_HEADER_OE_X2%5_22 1.69514e-17
C_x_PM_HEADER_OE_X2%5_c3 VSS x_PM_HEADER_OE_X2%5_21 3.35408e-17
C_x_PM_HEADER_OE_X2%5_c4 VSS x_PM_HEADER_OE_X2%5_20 8.24565e-18
C_x_PM_HEADER_OE_X2%5_c5 VSS x_PM_HEADER_OE_X2%5_19 4.32871e-17
C_x_PM_HEADER_OE_X2%5_c6 VSS N_5_M1_s 5.19564e-17
C_x_PM_HEADER_OE_X2%5_c7 VSS N_5_M3_s 3.09924e-17
C_x_PM_HEADER_OE_X2%5_c8 VSS N_5_M2_g 7.9842e-17
C_x_PM_HEADER_OE_X2%5_c9 VSS N_5_M4_g 4.7474e-17
R_x_PM_HEADER_OE_X2%5_r10 x_PM_HEADER_OE_X2%5_30 x_PM_HEADER_OE_X2%5_28 3.38
R_x_PM_HEADER_OE_X2%5_r11 x_PM_HEADER_OE_X2%5_28 x_PM_HEADER_OE_X2%5_26 25.0012
R_x_PM_HEADER_OE_X2%5_r12 x_PM_HEADER_OE_X2%5_26 x_PM_HEADER_OE_X2%5_24 1.88643
R_x_PM_HEADER_OE_X2%5_r13 x_PM_HEADER_OE_X2%5_26 x_PM_HEADER_OE_X2%5_23 0.366429
R_x_PM_HEADER_OE_X2%5_r14 x_PM_HEADER_OE_X2%5_24 x_PM_HEADER_OE_X2%5_21 0.212317
R_x_PM_HEADER_OE_X2%5_r15 x_PM_HEADER_OE_X2%5_22 x_PM_HEADER_OE_X2%5_21 0.95
R_x_PM_HEADER_OE_X2%5_r16 x_PM_HEADER_OE_X2%5_23 x_PM_HEADER_OE_X2%5_19 0.212317
R_x_PM_HEADER_OE_X2%5_r17 x_PM_HEADER_OE_X2%5_20 x_PM_HEADER_OE_X2%5_19 0.95
R_x_PM_HEADER_OE_X2%5_r18 x_PM_HEADER_OE_X2%5_22 x_PM_HEADER_OE_X2%5_15 0.212317
R_x_PM_HEADER_OE_X2%5_r19 N_5_M1_s x_PM_HEADER_OE_X2%5_15 1.07214
R_x_PM_HEADER_OE_X2%5_r20 x_PM_HEADER_OE_X2%5_20 x_PM_HEADER_OE_X2%5_11 0.212317
R_x_PM_HEADER_OE_X2%5_r21 N_5_M3_s x_PM_HEADER_OE_X2%5_11 0.665
R_x_PM_HEADER_OE_X2%5_r22 x_PM_HEADER_OE_X2%5_30 x_PM_HEADER_OE_X2%5_5 1.95
R_x_PM_HEADER_OE_X2%5_r23 N_5_M2_g x_PM_HEADER_OE_X2%5_5 84.24
R_x_PM_HEADER_OE_X2%5_r24 x_PM_HEADER_OE_X2%5_30 x_PM_HEADER_OE_X2%5_1 1.95
R_x_PM_HEADER_OE_X2%5_r25 N_5_M4_g x_PM_HEADER_OE_X2%5_1 42.9
C_x_PM_HEADER_OE_X2%SLEEPOUT_c0 VSS N_SLEEPOUT_M4_d 1.82552e-16
R_x_PM_HEADER_OE_X2%SLEEPOUT_r1 N_SLEEPOUT_M2_d SLEEPOUT 1.93
R_x_PM_HEADER_OE_X2%SLEEPOUT_r2 SLEEPOUT N_SLEEPOUT_M4_d 1.59
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HEADER_OE_X4.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HEADER_OE_X4 VDD VSS SLEEP VVDD SLEEPOUT
*.PININFO VDD:P VSS:G SLEEP:I VVDD:P SLEEPOUT:O
*.EQN SLEEPOUT=SLEEP
M_M2 N_VVDD_M0_d N_SLEEP_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.540000U L=0.050000U
M_M3 N_VDD_M1_d N_SLEEP_M1_g N_5_M1_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_SLEEPOUT_M2_d N_5_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_VSS_M3_d N_SLEEP_M3_g N_5_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_SLEEPOUT_M4_d N_5_M4_g N_VSS_M3_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_HEADER_OE_X4%VDD_c0 VSS x_PM_HEADER_OE_X4%VDD_39 2.25198e-17
C_x_PM_HEADER_OE_X4%VDD_c1 VSS x_PM_HEADER_OE_X4%VDD_36 6.16484e-18
C_x_PM_HEADER_OE_X4%VDD_c2 VSS x_PM_HEADER_OE_X4%VDD_26 2.61574e-16
C_x_PM_HEADER_OE_X4%VDD_c3 VSS N_VDD_M1_d 9.43763e-17
C_x_PM_HEADER_OE_X4%VDD_c4 VSS x_PM_HEADER_OE_X4%VDD_19 1.94709e-17
C_x_PM_HEADER_OE_X4%VDD_c5 VSS x_PM_HEADER_OE_X4%VDD_18 2.99256e-17
C_x_PM_HEADER_OE_X4%VDD_c6 VSS N_VDD_M0_s 2.41234e-17
C_x_PM_HEADER_OE_X4%VDD_c7 VSS x_PM_HEADER_OE_X4%VDD_13 1.92462e-17
C_x_PM_HEADER_OE_X4%VDD_c8 VSS x_PM_HEADER_OE_X4%VDD_12 2.334e-16
C_x_PM_HEADER_OE_X4%VDD_c9 VSS x_PM_HEADER_OE_X4%VDD_9 5.90809e-16
R_x_PM_HEADER_OE_X4%VDD_r10 x_PM_HEADER_OE_X4%VDD_39 VDD 0.13879
R_x_PM_HEADER_OE_X4%VDD_r11 x_PM_HEADER_OE_X4%VDD_35 VDD 0.403043
R_x_PM_HEADER_OE_X4%VDD_r12 x_PM_HEADER_OE_X4%VDD_26 VDD 0.13879
R_x_PM_HEADER_OE_X4%VDD_r13 VDD x_PM_HEADER_OE_X4%VDD_26 3.84471
R_x_PM_HEADER_OE_X4%VDD_r14 x_PM_HEADER_OE_X4%VDD_36 x_PM_HEADER_OE_X4%VDD_25 0.132285
R_x_PM_HEADER_OE_X4%VDD_r15 x_PM_HEADER_OE_X4%VDD_25 x_PM_HEADER_OE_X4%VDD_39 0.648235
R_x_PM_HEADER_OE_X4%VDD_r16 x_PM_HEADER_OE_X4%VDD_36 x_PM_HEADER_OE_X4%VDD_20 0.068038
R_x_PM_HEADER_OE_X4%VDD_r17 N_VDD_M1_d x_PM_HEADER_OE_X4%VDD_20 1.35815
R_x_PM_HEADER_OE_X4%VDD_r18 x_PM_HEADER_OE_X4%VDD_35 x_PM_HEADER_OE_X4%VDD_19 0.075321
R_x_PM_HEADER_OE_X4%VDD_r19 x_PM_HEADER_OE_X4%VDD_36 x_PM_HEADER_OE_X4%VDD_18 0.132285
R_x_PM_HEADER_OE_X4%VDD_r20 x_PM_HEADER_OE_X4%VDD_19 x_PM_HEADER_OE_X4%VDD_18 1.01706
R_x_PM_HEADER_OE_X4%VDD_r21 N_VDD_M0_s x_PM_HEADER_OE_X4%VDD_35 0.665
R_x_PM_HEADER_OE_X4%VDD_r22 VDD x_PM_HEADER_OE_X4%VDD_13 0.140282
R_x_PM_HEADER_OE_X4%VDD_r23 VDD x_PM_HEADER_OE_X4%VDD_12 0.143612
R_x_PM_HEADER_OE_X4%VDD_r24 x_PM_HEADER_OE_X4%VDD_13 x_PM_HEADER_OE_X4%VDD_12 7.68941
R_x_PM_HEADER_OE_X4%VDD_r25 VDD x_PM_HEADER_OE_X4%VDD_9 9.15353
C_x_PM_HEADER_OE_X4%VSS_c0 VSS x_PM_HEADER_OE_X4%VSS_36 2.79737e-17
C_x_PM_HEADER_OE_X4%VSS_c1 VSS x_PM_HEADER_OE_X4%VSS_33 2.8975e-18
C_x_PM_HEADER_OE_X4%VSS_c2 VSS x_PM_HEADER_OE_X4%VSS_31 2.334e-16
C_x_PM_HEADER_OE_X4%VSS_c3 VSS VSS 2.61602e-16
C_x_PM_HEADER_OE_X4%VSS_c4 VSS N_VSS_M3_d 3.37138e-17
C_x_PM_HEADER_OE_X4%VSS_c5 VSS x_PM_HEADER_OE_X4%VSS_14 1.06907e-17
C_x_PM_HEADER_OE_X4%VSS_c6 VSS x_PM_HEADER_OE_X4%VSS_13 6.97299e-17
C_x_PM_HEADER_OE_X4%VSS_c7 VSS x_PM_HEADER_OE_X4%VSS_10 5.90809e-16
C_x_PM_HEADER_OE_X4%VSS_c8 VSS x_PM_HEADER_OE_X4%VSS_9 1.92462e-17
R_x_PM_HEADER_OE_X4%VSS_r9 x_PM_HEADER_OE_X4%VSS_36 VSS 0.13879
R_x_PM_HEADER_OE_X4%VSS_r10 x_PM_HEADER_OE_X4%VSS_31 VSS 0.138985
R_x_PM_HEADER_OE_X4%VSS_r11 x_PM_HEADER_OE_X4%VSS_33 x_PM_HEADER_OE_X4%VSS_22 0.073144
R_x_PM_HEADER_OE_X4%VSS_r12 x_PM_HEADER_OE_X4%VSS_22 x_PM_HEADER_OE_X4%VSS_36 0.726471
R_x_PM_HEADER_OE_X4%VSS_r13 x_PM_HEADER_OE_X4%VSS_33 x_PM_HEADER_OE_X4%VSS_17 0.145286
R_x_PM_HEADER_OE_X4%VSS_r14 N_VSS_M3_d x_PM_HEADER_OE_X4%VSS_17 0.475
R_x_PM_HEADER_OE_X4%VSS_r15 x_PM_HEADER_OE_X4%VSS_14 VSS 0.138595
R_x_PM_HEADER_OE_X4%VSS_r16 VSS x_PM_HEADER_OE_X4%VSS_14 1.16235
R_x_PM_HEADER_OE_X4%VSS_r17 x_PM_HEADER_OE_X4%VSS_33 x_PM_HEADER_OE_X4%VSS_13 0.073144
R_x_PM_HEADER_OE_X4%VSS_r18 VSS x_PM_HEADER_OE_X4%VSS_13 0.279412
R_x_PM_HEADER_OE_X4%VSS_r19 VSS x_PM_HEADER_OE_X4%VSS_10 9.15353
R_x_PM_HEADER_OE_X4%VSS_r20 VSS x_PM_HEADER_OE_X4%VSS_9 0.140282
R_x_PM_HEADER_OE_X4%VSS_r21 x_PM_HEADER_OE_X4%VSS_9 x_PM_HEADER_OE_X4%VSS_31 7.68941
C_x_PM_HEADER_OE_X4%SLEEP_c0 VSS SLEEP 1.04045e-17
C_x_PM_HEADER_OE_X4%SLEEP_c1 VSS x_PM_HEADER_OE_X4%SLEEP_19 6.83493e-18
C_x_PM_HEADER_OE_X4%SLEEP_c2 VSS x_PM_HEADER_OE_X4%SLEEP_17 7.81052e-17
C_x_PM_HEADER_OE_X4%SLEEP_c3 VSS x_PM_HEADER_OE_X4%SLEEP_16 6.19591e-18
C_x_PM_HEADER_OE_X4%SLEEP_c4 VSS N_SLEEP_M1_g 4.34409e-17
C_x_PM_HEADER_OE_X4%SLEEP_c5 VSS N_SLEEP_M3_g 4.48171e-17
C_x_PM_HEADER_OE_X4%SLEEP_c6 VSS N_SLEEP_M0_g 7.84134e-17
R_x_PM_HEADER_OE_X4%SLEEP_r7 x_PM_HEADER_OE_X4%SLEEP_24 SLEEP 0.162857
R_x_PM_HEADER_OE_X4%SLEEP_r8 x_PM_HEADER_OE_X4%SLEEP_31 x_PM_HEADER_OE_X4%SLEEP_19 4.74714
R_x_PM_HEADER_OE_X4%SLEEP_r9 x_PM_HEADER_OE_X4%SLEEP_30 x_PM_HEADER_OE_X4%SLEEP_19 4.74714
R_x_PM_HEADER_OE_X4%SLEEP_r10 x_PM_HEADER_OE_X4%SLEEP_19 x_PM_HEADER_OE_X4%SLEEP_17 25.0012
R_x_PM_HEADER_OE_X4%SLEEP_r11 x_PM_HEADER_OE_X4%SLEEP_28 x_PM_HEADER_OE_X4%SLEEP_16 4.7687
R_x_PM_HEADER_OE_X4%SLEEP_r12 x_PM_HEADER_OE_X4%SLEEP_16 x_PM_HEADER_OE_X4%SLEEP_14 25.0012
R_x_PM_HEADER_OE_X4%SLEEP_r13 x_PM_HEADER_OE_X4%SLEEP_17 x_PM_HEADER_OE_X4%SLEEP_14 1.73375
R_x_PM_HEADER_OE_X4%SLEEP_r14 x_PM_HEADER_OE_X4%SLEEP_24 x_PM_HEADER_OE_X4%SLEEP_13 0.095
R_x_PM_HEADER_OE_X4%SLEEP_r15 x_PM_HEADER_OE_X4%SLEEP_14 x_PM_HEADER_OE_X4%SLEEP_13 0.130625
R_x_PM_HEADER_OE_X4%SLEEP_r16 N_SLEEP_M1_g x_PM_HEADER_OE_X4%SLEEP_31 39.39
R_x_PM_HEADER_OE_X4%SLEEP_r17 N_SLEEP_M3_g x_PM_HEADER_OE_X4%SLEEP_30 46.8
R_x_PM_HEADER_OE_X4%SLEEP_r18 N_SLEEP_M0_g x_PM_HEADER_OE_X4%SLEEP_28 63.18
C_x_PM_HEADER_OE_X4%VVDD_c0 VSS VVDD 6.21827e-17
R_x_PM_HEADER_OE_X4%VVDD_r1 VVDD N_VVDD_M0_d 0.025909
C_x_PM_HEADER_OE_X4%5_c0 VSS x_PM_HEADER_OE_X4%5_28 1.17342e-17
C_x_PM_HEADER_OE_X4%5_c1 VSS x_PM_HEADER_OE_X4%5_24 7.38772e-17
C_x_PM_HEADER_OE_X4%5_c2 VSS x_PM_HEADER_OE_X4%5_20 2.44509e-17
C_x_PM_HEADER_OE_X4%5_c3 VSS x_PM_HEADER_OE_X4%5_19 4.1658e-17
C_x_PM_HEADER_OE_X4%5_c4 VSS x_PM_HEADER_OE_X4%5_18 1.55176e-17
C_x_PM_HEADER_OE_X4%5_c5 VSS x_PM_HEADER_OE_X4%5_17 5.65855e-17
C_x_PM_HEADER_OE_X4%5_c6 VSS N_5_M1_s 2.52104e-17
C_x_PM_HEADER_OE_X4%5_c7 VSS x_PM_HEADER_OE_X4%5_12 4.64887e-17
C_x_PM_HEADER_OE_X4%5_c8 VSS N_5_M2_g 7.21816e-17
C_x_PM_HEADER_OE_X4%5_c9 VSS N_5_M4_g 5.56869e-17
R_x_PM_HEADER_OE_X4%5_r10 x_PM_HEADER_OE_X4%5_28 x_PM_HEADER_OE_X4%5_26 3.38
R_x_PM_HEADER_OE_X4%5_r11 x_PM_HEADER_OE_X4%5_26 x_PM_HEADER_OE_X4%5_24 25.0012
R_x_PM_HEADER_OE_X4%5_r12 x_PM_HEADER_OE_X4%5_24 x_PM_HEADER_OE_X4%5_22 0.067857
R_x_PM_HEADER_OE_X4%5_r13 x_PM_HEADER_OE_X4%5_24 x_PM_HEADER_OE_X4%5_21 1.37071
R_x_PM_HEADER_OE_X4%5_r14 x_PM_HEADER_OE_X4%5_21 x_PM_HEADER_OE_X4%5_19 0.212317
R_x_PM_HEADER_OE_X4%5_r15 x_PM_HEADER_OE_X4%5_20 x_PM_HEADER_OE_X4%5_19 0.787143
R_x_PM_HEADER_OE_X4%5_r16 x_PM_HEADER_OE_X4%5_22 x_PM_HEADER_OE_X4%5_17 0.212317
R_x_PM_HEADER_OE_X4%5_r17 x_PM_HEADER_OE_X4%5_18 x_PM_HEADER_OE_X4%5_17 1.00429
R_x_PM_HEADER_OE_X4%5_r18 x_PM_HEADER_OE_X4%5_18 x_PM_HEADER_OE_X4%5_13 0.212317
R_x_PM_HEADER_OE_X4%5_r19 N_5_M1_s x_PM_HEADER_OE_X4%5_13 0.285
R_x_PM_HEADER_OE_X4%5_r20 x_PM_HEADER_OE_X4%5_20 x_PM_HEADER_OE_X4%5_12 0.241334
R_x_PM_HEADER_OE_X4%5_r21 x_PM_HEADER_OE_X4%5_12 N_5_M3_s 0.319139
R_x_PM_HEADER_OE_X4%5_r22 x_PM_HEADER_OE_X4%5_28 x_PM_HEADER_OE_X4%5_5 1.95
R_x_PM_HEADER_OE_X4%5_r23 N_5_M2_g x_PM_HEADER_OE_X4%5_5 50.7
R_x_PM_HEADER_OE_X4%5_r24 x_PM_HEADER_OE_X4%5_28 x_PM_HEADER_OE_X4%5_1 1.95
R_x_PM_HEADER_OE_X4%5_r25 N_5_M4_g x_PM_HEADER_OE_X4%5_1 46.02
C_x_PM_HEADER_OE_X4%SLEEPOUT_c0 VSS N_SLEEPOUT_M4_d 1.30343e-16
R_x_PM_HEADER_OE_X4%SLEEPOUT_r1 N_SLEEPOUT_M2_d SLEEPOUT 1.34056
R_x_PM_HEADER_OE_X4%SLEEPOUT_r2 SLEEPOUT N_SLEEPOUT_M4_d 0.728333
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HEADER_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HEADER_X1 VSS VDD SLEEP VVDD
*.PININFO VSS:G VDD:P SLEEP:I VVDD:P
M_M0 N_VVDD_M0_d N_SLEEP_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
c_1 VSS 0 3.89615e-17
C_x_PM_HEADER_X1%VDD_c0 x_PM_HEADER_X1%VDD_6 VSS 4.62241e-17
C_x_PM_HEADER_X1%VDD_c1 N_VDD_M0_s VSS 4.32335e-17
R_x_PM_HEADER_X1%VDD_r2 x_PM_HEADER_X1%VDD_6 VDD 0.089412
R_x_PM_HEADER_X1%VDD_r3 x_PM_HEADER_X1%VDD_2 x_PM_HEADER_X1%VDD_6 0.244544
R_x_PM_HEADER_X1%VDD_r4 x_PM_HEADER_X1%VDD_2 N_VDD_M0_s 1.08412
C_x_PM_HEADER_X1%SLEEP_c0 x_PM_HEADER_X1%SLEEP_16 VSS 1.78662e-17
C_x_PM_HEADER_X1%SLEEP_c1 x_PM_HEADER_X1%SLEEP_14 VSS 4.34136e-17
C_x_PM_HEADER_X1%SLEEP_c2 SLEEP VSS 1.92634e-17
C_x_PM_HEADER_X1%SLEEP_c3 N_SLEEP_M0_g VSS 7.02547e-17
R_x_PM_HEADER_X1%SLEEP_r4 x_PM_HEADER_X1%SLEEP_16 x_PM_HEADER_X1%SLEEP_20 4.74714
R_x_PM_HEADER_X1%SLEEP_r5 x_PM_HEADER_X1%SLEEP_14 x_PM_HEADER_X1%SLEEP_16 25.0012
R_x_PM_HEADER_X1%SLEEP_r6 SLEEP x_PM_HEADER_X1%SLEEP_14 0.007308
R_x_PM_HEADER_X1%SLEEP_r7 x_PM_HEADER_X1%SLEEP_20 N_SLEEP_M0_g 79.95
C_x_PM_HEADER_X1%VVDD_c0 VVDD VSS 1.05031e-16
R_x_PM_HEADER_X1%VVDD_r1 VVDD N_VVDD_M0_d 0.28913
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HEADER_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HEADER_X2 VSS VDD SLEEP VVDD
*.PININFO VSS:G VDD:P SLEEP:I VVDD:P
M_M0 N_VVDD_M0_d N_SLEEP_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
c_1 VSS 0 3.9811e-17
C_x_PM_HEADER_X2%VDD_c0 x_PM_HEADER_X2%VDD_6 VSS 5.54653e-17
C_x_PM_HEADER_X2%VDD_c1 N_VDD_M0_s VSS 5.04762e-17
R_x_PM_HEADER_X2%VDD_r2 x_PM_HEADER_X2%VDD_6 VDD 0.100588
R_x_PM_HEADER_X2%VDD_r3 x_PM_HEADER_X2%VDD_2 x_PM_HEADER_X2%VDD_6 0.244544
R_x_PM_HEADER_X2%VDD_r4 x_PM_HEADER_X2%VDD_2 N_VDD_M0_s 0.659412
C_x_PM_HEADER_X2%SLEEP_c0 x_PM_HEADER_X2%SLEEP_17 VSS 1.54781e-17
C_x_PM_HEADER_X2%SLEEP_c1 x_PM_HEADER_X2%SLEEP_15 VSS 7.63449e-18
C_x_PM_HEADER_X2%SLEEP_c2 x_PM_HEADER_X2%SLEEP_14 VSS 4.20998e-17
C_x_PM_HEADER_X2%SLEEP_c3 N_SLEEP_M0_g VSS 8.51612e-17
R_x_PM_HEADER_X2%SLEEP_r4 x_PM_HEADER_X2%SLEEP_17 x_PM_HEADER_X2%SLEEP_21 4.74714
R_x_PM_HEADER_X2%SLEEP_r5 x_PM_HEADER_X2%SLEEP_15 x_PM_HEADER_X2%SLEEP_17 25.0012
R_x_PM_HEADER_X2%SLEEP_r6 x_PM_HEADER_X2%SLEEP_14 x_PM_HEADER_X2%SLEEP_15 0.234706
R_x_PM_HEADER_X2%SLEEP_r7 SLEEP x_PM_HEADER_X2%SLEEP_14 0.022353
R_x_PM_HEADER_X2%SLEEP_r8 x_PM_HEADER_X2%SLEEP_21 N_SLEEP_M0_g 85.02
C_x_PM_HEADER_X2%VVDD_c0 VVDD VSS 1.34715e-16
R_x_PM_HEADER_X2%VVDD_r1 VVDD N_VVDD_M0_d 0.767917
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HEADER_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT HEADER_X4 VSS VDD SLEEP VVDD
*.PININFO VSS:G VDD:P SLEEP:I VVDD:P
M_M0 N_VVDD_M0_d N_SLEEP_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.540000U L=0.050000U
c_1 VSS 0 4.05828e-17
C_x_PM_HEADER_X4%VDD_c0 VDD VSS 3.4842e-17
C_x_PM_HEADER_X4%VDD_c1 x_PM_HEADER_X4%VDD_6 VSS 1.09852e-17
C_x_PM_HEADER_X4%VDD_c2 N_VDD_M0_s VSS 4.10245e-17
R_x_PM_HEADER_X4%VDD_r3 x_PM_HEADER_X4%VDD_6 VDD 0.167647
R_x_PM_HEADER_X4%VDD_r4 x_PM_HEADER_X4%VDD_2 x_PM_HEADER_X4%VDD_6 0.250237
R_x_PM_HEADER_X4%VDD_r5 x_PM_HEADER_X4%VDD_2 N_VDD_M0_s 0.581875
C_x_PM_HEADER_X4%SLEEP_c0 x_PM_HEADER_X4%SLEEP_8 VSS 1.54128e-17
C_x_PM_HEADER_X4%SLEEP_c1 x_PM_HEADER_X4%SLEEP_5 VSS 3.05992e-17
C_x_PM_HEADER_X4%SLEEP_c2 N_SLEEP_M0_g VSS 9.59549e-17
C_x_PM_HEADER_X4%SLEEP_c3 x_PM_HEADER_X4%SLEEP_1 VSS 1.3451e-17
R_x_PM_HEADER_X4%SLEEP_r4 x_PM_HEADER_X4%SLEEP_9 x_PM_HEADER_X4%SLEEP_11 25.0012
R_x_PM_HEADER_X4%SLEEP_r5 x_PM_HEADER_X4%SLEEP_8 x_PM_HEADER_X4%SLEEP_9 0.125601
R_x_PM_HEADER_X4%SLEEP_r6 x_PM_HEADER_X4%SLEEP_5 x_PM_HEADER_X4%SLEEP_8 0.105619
R_x_PM_HEADER_X4%SLEEP_r7 x_PM_HEADER_X4%SLEEP_5 SLEEP 0.268235
R_x_PM_HEADER_X4%SLEEP_r8 x_PM_HEADER_X4%SLEEP_1 x_PM_HEADER_X4%SLEEP_11 5.34012
R_x_PM_HEADER_X4%SLEEP_r9 x_PM_HEADER_X4%SLEEP_1 N_SLEEP_M0_g 86.58
C_x_PM_HEADER_X4%VVDD_c0 VVDD VSS 9.72984e-17
R_x_PM_HEADER_X4%VVDD_r1 VVDD N_VVDD_M0_d 1.61952
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE0N_X1.                                                  *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE0N_X1 VDD VSS A EN Z
*.PININFO VDD:P VSS:G A:I EN:I Z:O
*.EQN Z=(A * EN)
M_M3 N_3_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.205000U L=0.050000U
M_M4 N_VDD_M1_d N_EN_M1_g N_3_M0_d VDD PMOS_VTL W=0.205000U L=0.050000U
M_M5 N_Z_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.205000U L=0.050000U
M_M0 7 N_A_M3_g N_3_M3_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M4_d N_EN_M4_g 7 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_Z_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.155000U L=0.050000U
C_x_PM_ISO_FENCE0N_X1%VDD_c0 VSS x_PM_ISO_FENCE0N_X1%VDD_39 2.66608e-17
C_x_PM_ISO_FENCE0N_X1%VDD_c1 VSS x_PM_ISO_FENCE0N_X1%VDD_36 2.96417e-18
C_x_PM_ISO_FENCE0N_X1%VDD_c2 VSS x_PM_ISO_FENCE0N_X1%VDD_26 2.61481e-16
C_x_PM_ISO_FENCE0N_X1%VDD_c3 VSS N_VDD_M1_d 2.60772e-17
C_x_PM_ISO_FENCE0N_X1%VDD_c4 VSS x_PM_ISO_FENCE0N_X1%VDD_19 1.90967e-17
C_x_PM_ISO_FENCE0N_X1%VDD_c5 VSS x_PM_ISO_FENCE0N_X1%VDD_18 1.97804e-17
C_x_PM_ISO_FENCE0N_X1%VDD_c6 VSS N_VDD_M0_s 1.52488e-17
C_x_PM_ISO_FENCE0N_X1%VDD_c7 VSS x_PM_ISO_FENCE0N_X1%VDD_13 1.92462e-17
C_x_PM_ISO_FENCE0N_X1%VDD_c8 VSS x_PM_ISO_FENCE0N_X1%VDD_12 2.334e-16
C_x_PM_ISO_FENCE0N_X1%VDD_c9 VSS x_PM_ISO_FENCE0N_X1%VDD_9 5.77955e-16
R_x_PM_ISO_FENCE0N_X1%VDD_r10 x_PM_ISO_FENCE0N_X1%VDD_39 VDD 0.13879
R_x_PM_ISO_FENCE0N_X1%VDD_r11 x_PM_ISO_FENCE0N_X1%VDD_35 VDD 0.392137
R_x_PM_ISO_FENCE0N_X1%VDD_r12 x_PM_ISO_FENCE0N_X1%VDD_26 VDD 0.13879
R_x_PM_ISO_FENCE0N_X1%VDD_r13 VDD x_PM_ISO_FENCE0N_X1%VDD_26 3.84471
R_x_PM_ISO_FENCE0N_X1%VDD_r14 x_PM_ISO_FENCE0N_X1%VDD_36 x_PM_ISO_FENCE0N_X1%VDD_25 0.073144
R_x_PM_ISO_FENCE0N_X1%VDD_r15 x_PM_ISO_FENCE0N_X1%VDD_25 x_PM_ISO_FENCE0N_X1%VDD_39 0.715294
R_x_PM_ISO_FENCE0N_X1%VDD_r16 x_PM_ISO_FENCE0N_X1%VDD_36 x_PM_ISO_FENCE0N_X1%VDD_20 0.145286
R_x_PM_ISO_FENCE0N_X1%VDD_r17 N_VDD_M1_d x_PM_ISO_FENCE0N_X1%VDD_20 1.01786
R_x_PM_ISO_FENCE0N_X1%VDD_r18 x_PM_ISO_FENCE0N_X1%VDD_35 x_PM_ISO_FENCE0N_X1%VDD_19 0.0753
R_x_PM_ISO_FENCE0N_X1%VDD_r19 x_PM_ISO_FENCE0N_X1%VDD_36 x_PM_ISO_FENCE0N_X1%VDD_18 0.073144
R_x_PM_ISO_FENCE0N_X1%VDD_r20 x_PM_ISO_FENCE0N_X1%VDD_19 x_PM_ISO_FENCE0N_X1%VDD_18 0.681765
R_x_PM_ISO_FENCE0N_X1%VDD_r21 N_VDD_M0_s x_PM_ISO_FENCE0N_X1%VDD_35 1.01786
R_x_PM_ISO_FENCE0N_X1%VDD_r22 VDD x_PM_ISO_FENCE0N_X1%VDD_13 0.140282
R_x_PM_ISO_FENCE0N_X1%VDD_r23 VDD x_PM_ISO_FENCE0N_X1%VDD_12 0.143516
R_x_PM_ISO_FENCE0N_X1%VDD_r24 x_PM_ISO_FENCE0N_X1%VDD_13 x_PM_ISO_FENCE0N_X1%VDD_12 7.68941
R_x_PM_ISO_FENCE0N_X1%VDD_r25 VDD x_PM_ISO_FENCE0N_X1%VDD_9 8.94118
C_x_PM_ISO_FENCE0N_X1%VSS_c0 VSS x_PM_ISO_FENCE0N_X1%VSS_36 3.62977e-17
C_x_PM_ISO_FENCE0N_X1%VSS_c1 VSS x_PM_ISO_FENCE0N_X1%VSS_33 2.80728e-18
C_x_PM_ISO_FENCE0N_X1%VSS_c2 VSS x_PM_ISO_FENCE0N_X1%VSS_31 2.334e-16
C_x_PM_ISO_FENCE0N_X1%VSS_c3 VSS VSS 2.61603e-16
C_x_PM_ISO_FENCE0N_X1%VSS_c4 VSS N_VSS_M4_d 3.1623e-17
C_x_PM_ISO_FENCE0N_X1%VSS_c5 VSS x_PM_ISO_FENCE0N_X1%VSS_14 1.07541e-17
C_x_PM_ISO_FENCE0N_X1%VSS_c6 VSS x_PM_ISO_FENCE0N_X1%VSS_13 4.82501e-17
C_x_PM_ISO_FENCE0N_X1%VSS_c7 VSS x_PM_ISO_FENCE0N_X1%VSS_10 5.77955e-16
C_x_PM_ISO_FENCE0N_X1%VSS_c8 VSS x_PM_ISO_FENCE0N_X1%VSS_9 1.92462e-17
R_x_PM_ISO_FENCE0N_X1%VSS_r9 x_PM_ISO_FENCE0N_X1%VSS_36 VSS 0.13879
R_x_PM_ISO_FENCE0N_X1%VSS_r10 x_PM_ISO_FENCE0N_X1%VSS_31 VSS 0.138985
R_x_PM_ISO_FENCE0N_X1%VSS_r11 x_PM_ISO_FENCE0N_X1%VSS_33 x_PM_ISO_FENCE0N_X1%VSS_22 0.073144
R_x_PM_ISO_FENCE0N_X1%VSS_r12 x_PM_ISO_FENCE0N_X1%VSS_22 x_PM_ISO_FENCE0N_X1%VSS_36 0.715294
R_x_PM_ISO_FENCE0N_X1%VSS_r13 x_PM_ISO_FENCE0N_X1%VSS_33 x_PM_ISO_FENCE0N_X1%VSS_17 0.145286
R_x_PM_ISO_FENCE0N_X1%VSS_r14 N_VSS_M4_d x_PM_ISO_FENCE0N_X1%VSS_17 0.366429
R_x_PM_ISO_FENCE0N_X1%VSS_r15 x_PM_ISO_FENCE0N_X1%VSS_14 VSS 0.138595
R_x_PM_ISO_FENCE0N_X1%VSS_r16 VSS x_PM_ISO_FENCE0N_X1%VSS_14 0.95
R_x_PM_ISO_FENCE0N_X1%VSS_r17 x_PM_ISO_FENCE0N_X1%VSS_33 x_PM_ISO_FENCE0N_X1%VSS_13 0.073144
R_x_PM_ISO_FENCE0N_X1%VSS_r18 VSS x_PM_ISO_FENCE0N_X1%VSS_13 0.078235
R_x_PM_ISO_FENCE0N_X1%VSS_r19 VSS x_PM_ISO_FENCE0N_X1%VSS_10 8.94118
R_x_PM_ISO_FENCE0N_X1%VSS_r20 VSS x_PM_ISO_FENCE0N_X1%VSS_9 0.140282
R_x_PM_ISO_FENCE0N_X1%VSS_r21 x_PM_ISO_FENCE0N_X1%VSS_9 x_PM_ISO_FENCE0N_X1%VSS_31 7.68941
C_x_PM_ISO_FENCE0N_X1%3_c0 VSS x_PM_ISO_FENCE0N_X1%3_30 1.26691e-17
C_x_PM_ISO_FENCE0N_X1%3_c1 VSS x_PM_ISO_FENCE0N_X1%3_26 1.13553e-16
C_x_PM_ISO_FENCE0N_X1%3_c2 VSS x_PM_ISO_FENCE0N_X1%3_22 7.80211e-18
C_x_PM_ISO_FENCE0N_X1%3_c3 VSS x_PM_ISO_FENCE0N_X1%3_21 3.18073e-17
C_x_PM_ISO_FENCE0N_X1%3_c4 VSS N_3_M0_d 1.96711e-17
C_x_PM_ISO_FENCE0N_X1%3_c5 VSS x_PM_ISO_FENCE0N_X1%3_16 5.45413e-18
C_x_PM_ISO_FENCE0N_X1%3_c6 VSS x_PM_ISO_FENCE0N_X1%3_15 8.21492e-17
C_x_PM_ISO_FENCE0N_X1%3_c7 VSS N_3_M3_s 1.4575e-17
C_x_PM_ISO_FENCE0N_X1%3_c8 VSS N_3_M2_g 7.04725e-17
C_x_PM_ISO_FENCE0N_X1%3_c9 VSS N_3_M5_g 4.89384e-17
R_x_PM_ISO_FENCE0N_X1%3_r10 x_PM_ISO_FENCE0N_X1%3_30 x_PM_ISO_FENCE0N_X1%3_28 4.42
R_x_PM_ISO_FENCE0N_X1%3_r11 x_PM_ISO_FENCE0N_X1%3_28 x_PM_ISO_FENCE0N_X1%3_26 25.0012
R_x_PM_ISO_FENCE0N_X1%3_r12 x_PM_ISO_FENCE0N_X1%3_26 x_PM_ISO_FENCE0N_X1%3_24 1.64214
R_x_PM_ISO_FENCE0N_X1%3_r13 x_PM_ISO_FENCE0N_X1%3_26 x_PM_ISO_FENCE0N_X1%3_23 1.01786
R_x_PM_ISO_FENCE0N_X1%3_r14 x_PM_ISO_FENCE0N_X1%3_24 x_PM_ISO_FENCE0N_X1%3_21 0.212317
R_x_PM_ISO_FENCE0N_X1%3_r15 x_PM_ISO_FENCE0N_X1%3_22 x_PM_ISO_FENCE0N_X1%3_21 0.895714
R_x_PM_ISO_FENCE0N_X1%3_r16 x_PM_ISO_FENCE0N_X1%3_22 x_PM_ISO_FENCE0N_X1%3_17 0.212317
R_x_PM_ISO_FENCE0N_X1%3_r17 N_3_M0_d x_PM_ISO_FENCE0N_X1%3_17 0.447857
R_x_PM_ISO_FENCE0N_X1%3_r18 x_PM_ISO_FENCE0N_X1%3_23 x_PM_ISO_FENCE0N_X1%3_15 0.212317
R_x_PM_ISO_FENCE0N_X1%3_r19 x_PM_ISO_FENCE0N_X1%3_16 x_PM_ISO_FENCE0N_X1%3_15 1.92714
R_x_PM_ISO_FENCE0N_X1%3_r20 x_PM_ISO_FENCE0N_X1%3_16 x_PM_ISO_FENCE0N_X1%3_11 0.212317
R_x_PM_ISO_FENCE0N_X1%3_r21 N_3_M3_s x_PM_ISO_FENCE0N_X1%3_11 0.149286
R_x_PM_ISO_FENCE0N_X1%3_r22 x_PM_ISO_FENCE0N_X1%3_30 x_PM_ISO_FENCE0N_X1%3_5 1.95
R_x_PM_ISO_FENCE0N_X1%3_r23 N_3_M2_g x_PM_ISO_FENCE0N_X1%3_5 75.27
R_x_PM_ISO_FENCE0N_X1%3_r24 x_PM_ISO_FENCE0N_X1%3_30 x_PM_ISO_FENCE0N_X1%3_1 1.95
R_x_PM_ISO_FENCE0N_X1%3_r25 N_3_M5_g x_PM_ISO_FENCE0N_X1%3_1 48.75
C_x_PM_ISO_FENCE0N_X1%A_c0 VSS x_PM_ISO_FENCE0N_X1%A_14 6.98642e-18
C_x_PM_ISO_FENCE0N_X1%A_c1 VSS x_PM_ISO_FENCE0N_X1%A_12 1.6438e-17
C_x_PM_ISO_FENCE0N_X1%A_c2 VSS N_A_M0_g 5.07797e-17
C_x_PM_ISO_FENCE0N_X1%A_c3 VSS N_A_M3_g 5.64124e-17
R_x_PM_ISO_FENCE0N_X1%A_r4 x_PM_ISO_FENCE0N_X1%A_18 x_PM_ISO_FENCE0N_X1%A_14 4.74714
R_x_PM_ISO_FENCE0N_X1%A_r5 x_PM_ISO_FENCE0N_X1%A_17 x_PM_ISO_FENCE0N_X1%A_14 4.74714
R_x_PM_ISO_FENCE0N_X1%A_r6 x_PM_ISO_FENCE0N_X1%A_14 x_PM_ISO_FENCE0N_X1%A_12 25.0012
R_x_PM_ISO_FENCE0N_X1%A_r7 x_PM_ISO_FENCE0N_X1%A_12 A 0.136562
R_x_PM_ISO_FENCE0N_X1%A_r8 N_A_M0_g x_PM_ISO_FENCE0N_X1%A_18 58.11
R_x_PM_ISO_FENCE0N_X1%A_r9 N_A_M3_g x_PM_ISO_FENCE0N_X1%A_17 63.96
C_x_PM_ISO_FENCE0N_X1%EN_c0 VSS x_PM_ISO_FENCE0N_X1%EN_14 8.68919e-18
C_x_PM_ISO_FENCE0N_X1%EN_c1 VSS x_PM_ISO_FENCE0N_X1%EN_12 5.29363e-17
C_x_PM_ISO_FENCE0N_X1%EN_c2 VSS N_EN_M1_g 7.14776e-17
C_x_PM_ISO_FENCE0N_X1%EN_c3 VSS N_EN_M4_g 4.31617e-17
R_x_PM_ISO_FENCE0N_X1%EN_r4 x_PM_ISO_FENCE0N_X1%EN_18 x_PM_ISO_FENCE0N_X1%EN_14 4.7687
R_x_PM_ISO_FENCE0N_X1%EN_r5 x_PM_ISO_FENCE0N_X1%EN_17 x_PM_ISO_FENCE0N_X1%EN_14 4.7687
R_x_PM_ISO_FENCE0N_X1%EN_r6 x_PM_ISO_FENCE0N_X1%EN_14 x_PM_ISO_FENCE0N_X1%EN_12 25.0012
R_x_PM_ISO_FENCE0N_X1%EN_r7 x_PM_ISO_FENCE0N_X1%EN_12 EN 0.169643
R_x_PM_ISO_FENCE0N_X1%EN_r8 N_EN_M1_g x_PM_ISO_FENCE0N_X1%EN_18 83.85
R_x_PM_ISO_FENCE0N_X1%EN_r9 N_EN_M4_g x_PM_ISO_FENCE0N_X1%EN_17 38.22
C_x_PM_ISO_FENCE0N_X1%Z_c0 VSS N_Z_M5_d 1.82344e-16
R_x_PM_ISO_FENCE0N_X1%Z_r1 N_Z_M2_d Z 1.93167
R_x_PM_ISO_FENCE0N_X1%Z_r2 Z N_Z_M5_d 1.67833
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE0N_X2.                                                  *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE0N_X2 VDD VSS A EN Z
*.PININFO VDD:P VSS:G A:I EN:I Z:O
*.EQN Z=(A * EN)
M_M3 N_3_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.205000U L=0.050000U
M_M4 N_VDD_M1_d N_EN_M1_g N_3_M0_d VDD PMOS_VTL W=0.205000U L=0.050000U
M_M5 N_Z_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M0 7 N_A_M3_g N_3_M3_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M4_d N_EN_M4_g 7 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_Z_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.305000U L=0.050000U
C_x_PM_ISO_FENCE0N_X2%VDD_c0 VSS x_PM_ISO_FENCE0N_X2%VDD_39 2.34057e-17
C_x_PM_ISO_FENCE0N_X2%VDD_c1 VSS x_PM_ISO_FENCE0N_X2%VDD_36 2.98731e-18
C_x_PM_ISO_FENCE0N_X2%VDD_c2 VSS x_PM_ISO_FENCE0N_X2%VDD_26 2.61481e-16
C_x_PM_ISO_FENCE0N_X2%VDD_c3 VSS N_VDD_M1_d 2.56497e-17
C_x_PM_ISO_FENCE0N_X2%VDD_c4 VSS x_PM_ISO_FENCE0N_X2%VDD_19 1.91198e-17
C_x_PM_ISO_FENCE0N_X2%VDD_c5 VSS x_PM_ISO_FENCE0N_X2%VDD_18 1.90531e-17
C_x_PM_ISO_FENCE0N_X2%VDD_c6 VSS N_VDD_M0_s 1.81419e-17
C_x_PM_ISO_FENCE0N_X2%VDD_c7 VSS x_PM_ISO_FENCE0N_X2%VDD_13 1.92462e-17
C_x_PM_ISO_FENCE0N_X2%VDD_c8 VSS x_PM_ISO_FENCE0N_X2%VDD_12 2.334e-16
C_x_PM_ISO_FENCE0N_X2%VDD_c9 VSS x_PM_ISO_FENCE0N_X2%VDD_9 5.77955e-16
R_x_PM_ISO_FENCE0N_X2%VDD_r10 x_PM_ISO_FENCE0N_X2%VDD_39 VDD 0.13879
R_x_PM_ISO_FENCE0N_X2%VDD_r11 x_PM_ISO_FENCE0N_X2%VDD_35 VDD 0.392137
R_x_PM_ISO_FENCE0N_X2%VDD_r12 x_PM_ISO_FENCE0N_X2%VDD_26 VDD 0.13879
R_x_PM_ISO_FENCE0N_X2%VDD_r13 VDD x_PM_ISO_FENCE0N_X2%VDD_26 3.84471
R_x_PM_ISO_FENCE0N_X2%VDD_r14 x_PM_ISO_FENCE0N_X2%VDD_36 x_PM_ISO_FENCE0N_X2%VDD_25 0.073144
R_x_PM_ISO_FENCE0N_X2%VDD_r15 x_PM_ISO_FENCE0N_X2%VDD_25 x_PM_ISO_FENCE0N_X2%VDD_39 0.715294
R_x_PM_ISO_FENCE0N_X2%VDD_r16 x_PM_ISO_FENCE0N_X2%VDD_36 x_PM_ISO_FENCE0N_X2%VDD_20 0.145286
R_x_PM_ISO_FENCE0N_X2%VDD_r17 N_VDD_M1_d x_PM_ISO_FENCE0N_X2%VDD_20 1.39786
R_x_PM_ISO_FENCE0N_X2%VDD_r18 x_PM_ISO_FENCE0N_X2%VDD_35 x_PM_ISO_FENCE0N_X2%VDD_19 0.0753
R_x_PM_ISO_FENCE0N_X2%VDD_r19 x_PM_ISO_FENCE0N_X2%VDD_36 x_PM_ISO_FENCE0N_X2%VDD_18 0.073144
R_x_PM_ISO_FENCE0N_X2%VDD_r20 x_PM_ISO_FENCE0N_X2%VDD_19 x_PM_ISO_FENCE0N_X2%VDD_18 0.681765
R_x_PM_ISO_FENCE0N_X2%VDD_r21 N_VDD_M0_s x_PM_ISO_FENCE0N_X2%VDD_35 1.39786
R_x_PM_ISO_FENCE0N_X2%VDD_r22 VDD x_PM_ISO_FENCE0N_X2%VDD_13 0.140282
R_x_PM_ISO_FENCE0N_X2%VDD_r23 VDD x_PM_ISO_FENCE0N_X2%VDD_12 0.143516
R_x_PM_ISO_FENCE0N_X2%VDD_r24 x_PM_ISO_FENCE0N_X2%VDD_13 x_PM_ISO_FENCE0N_X2%VDD_12 7.68941
R_x_PM_ISO_FENCE0N_X2%VDD_r25 VDD x_PM_ISO_FENCE0N_X2%VDD_9 8.94118
C_x_PM_ISO_FENCE0N_X2%VSS_c0 VSS x_PM_ISO_FENCE0N_X2%VSS_36 3.4366e-17
C_x_PM_ISO_FENCE0N_X2%VSS_c1 VSS x_PM_ISO_FENCE0N_X2%VSS_33 2.80728e-18
C_x_PM_ISO_FENCE0N_X2%VSS_c2 VSS x_PM_ISO_FENCE0N_X2%VSS_31 2.334e-16
C_x_PM_ISO_FENCE0N_X2%VSS_c3 VSS VSS 2.61603e-16
C_x_PM_ISO_FENCE0N_X2%VSS_c4 VSS N_VSS_M4_d 3.14155e-17
C_x_PM_ISO_FENCE0N_X2%VSS_c5 VSS x_PM_ISO_FENCE0N_X2%VSS_14 1.07541e-17
C_x_PM_ISO_FENCE0N_X2%VSS_c6 VSS x_PM_ISO_FENCE0N_X2%VSS_13 4.82638e-17
C_x_PM_ISO_FENCE0N_X2%VSS_c7 VSS x_PM_ISO_FENCE0N_X2%VSS_10 5.77955e-16
C_x_PM_ISO_FENCE0N_X2%VSS_c8 VSS x_PM_ISO_FENCE0N_X2%VSS_9 1.92462e-17
R_x_PM_ISO_FENCE0N_X2%VSS_r9 x_PM_ISO_FENCE0N_X2%VSS_36 VSS 0.13879
R_x_PM_ISO_FENCE0N_X2%VSS_r10 x_PM_ISO_FENCE0N_X2%VSS_31 VSS 0.138985
R_x_PM_ISO_FENCE0N_X2%VSS_r11 x_PM_ISO_FENCE0N_X2%VSS_33 x_PM_ISO_FENCE0N_X2%VSS_22 0.073144
R_x_PM_ISO_FENCE0N_X2%VSS_r12 x_PM_ISO_FENCE0N_X2%VSS_22 x_PM_ISO_FENCE0N_X2%VSS_36 0.715294
R_x_PM_ISO_FENCE0N_X2%VSS_r13 x_PM_ISO_FENCE0N_X2%VSS_33 x_PM_ISO_FENCE0N_X2%VSS_17 0.145286
R_x_PM_ISO_FENCE0N_X2%VSS_r14 N_VSS_M4_d x_PM_ISO_FENCE0N_X2%VSS_17 0.366429
R_x_PM_ISO_FENCE0N_X2%VSS_r15 x_PM_ISO_FENCE0N_X2%VSS_14 VSS 0.138595
R_x_PM_ISO_FENCE0N_X2%VSS_r16 VSS x_PM_ISO_FENCE0N_X2%VSS_14 0.95
R_x_PM_ISO_FENCE0N_X2%VSS_r17 x_PM_ISO_FENCE0N_X2%VSS_33 x_PM_ISO_FENCE0N_X2%VSS_13 0.073144
R_x_PM_ISO_FENCE0N_X2%VSS_r18 VSS x_PM_ISO_FENCE0N_X2%VSS_13 0.078235
R_x_PM_ISO_FENCE0N_X2%VSS_r19 VSS x_PM_ISO_FENCE0N_X2%VSS_10 8.94118
R_x_PM_ISO_FENCE0N_X2%VSS_r20 VSS x_PM_ISO_FENCE0N_X2%VSS_9 0.140282
R_x_PM_ISO_FENCE0N_X2%VSS_r21 x_PM_ISO_FENCE0N_X2%VSS_9 x_PM_ISO_FENCE0N_X2%VSS_31 7.68941
C_x_PM_ISO_FENCE0N_X2%3_c0 VSS x_PM_ISO_FENCE0N_X2%3_28 1.26812e-17
C_x_PM_ISO_FENCE0N_X2%3_c1 VSS x_PM_ISO_FENCE0N_X2%3_24 9.29683e-17
C_x_PM_ISO_FENCE0N_X2%3_c2 VSS x_PM_ISO_FENCE0N_X2%3_20 9.36867e-18
C_x_PM_ISO_FENCE0N_X2%3_c3 VSS x_PM_ISO_FENCE0N_X2%3_19 3.12594e-17
C_x_PM_ISO_FENCE0N_X2%3_c4 VSS x_PM_ISO_FENCE0N_X2%3_18 2.50522e-17
C_x_PM_ISO_FENCE0N_X2%3_c5 VSS x_PM_ISO_FENCE0N_X2%3_16 1.36045e-17
C_x_PM_ISO_FENCE0N_X2%3_c6 VSS x_PM_ISO_FENCE0N_X2%3_15 9.02149e-17
C_x_PM_ISO_FENCE0N_X2%3_c7 VSS N_3_M3_s 1.4575e-17
C_x_PM_ISO_FENCE0N_X2%3_c8 VSS N_3_M2_g 5.92588e-17
C_x_PM_ISO_FENCE0N_X2%3_c9 VSS N_3_M5_g 4.86356e-17
R_x_PM_ISO_FENCE0N_X2%3_r10 x_PM_ISO_FENCE0N_X2%3_28 x_PM_ISO_FENCE0N_X2%3_26 4.42
R_x_PM_ISO_FENCE0N_X2%3_r11 x_PM_ISO_FENCE0N_X2%3_26 x_PM_ISO_FENCE0N_X2%3_24 25.0012
R_x_PM_ISO_FENCE0N_X2%3_r12 x_PM_ISO_FENCE0N_X2%3_24 x_PM_ISO_FENCE0N_X2%3_22 0.990714
R_x_PM_ISO_FENCE0N_X2%3_r13 x_PM_ISO_FENCE0N_X2%3_24 x_PM_ISO_FENCE0N_X2%3_21 1.01786
R_x_PM_ISO_FENCE0N_X2%3_r14 x_PM_ISO_FENCE0N_X2%3_22 x_PM_ISO_FENCE0N_X2%3_19 0.212317
R_x_PM_ISO_FENCE0N_X2%3_r15 x_PM_ISO_FENCE0N_X2%3_20 x_PM_ISO_FENCE0N_X2%3_19 0.895714
R_x_PM_ISO_FENCE0N_X2%3_r16 x_PM_ISO_FENCE0N_X2%3_20 x_PM_ISO_FENCE0N_X2%3_18 0.212317
R_x_PM_ISO_FENCE0N_X2%3_r17 x_PM_ISO_FENCE0N_X2%3_18 N_3_M0_d 0.543196
R_x_PM_ISO_FENCE0N_X2%3_r18 x_PM_ISO_FENCE0N_X2%3_21 x_PM_ISO_FENCE0N_X2%3_15 0.212317
R_x_PM_ISO_FENCE0N_X2%3_r19 x_PM_ISO_FENCE0N_X2%3_16 x_PM_ISO_FENCE0N_X2%3_15 1.92714
R_x_PM_ISO_FENCE0N_X2%3_r20 x_PM_ISO_FENCE0N_X2%3_16 x_PM_ISO_FENCE0N_X2%3_11 0.212317
R_x_PM_ISO_FENCE0N_X2%3_r21 N_3_M3_s x_PM_ISO_FENCE0N_X2%3_11 0.149286
R_x_PM_ISO_FENCE0N_X2%3_r22 x_PM_ISO_FENCE0N_X2%3_28 x_PM_ISO_FENCE0N_X2%3_5 1.95
R_x_PM_ISO_FENCE0N_X2%3_r23 N_3_M2_g x_PM_ISO_FENCE0N_X2%3_5 47.97
R_x_PM_ISO_FENCE0N_X2%3_r24 x_PM_ISO_FENCE0N_X2%3_28 x_PM_ISO_FENCE0N_X2%3_1 1.95
R_x_PM_ISO_FENCE0N_X2%3_r25 N_3_M5_g x_PM_ISO_FENCE0N_X2%3_1 37.05
C_x_PM_ISO_FENCE0N_X2%A_c0 VSS x_PM_ISO_FENCE0N_X2%A_14 7.34584e-18
C_x_PM_ISO_FENCE0N_X2%A_c1 VSS x_PM_ISO_FENCE0N_X2%A_12 5.54593e-17
C_x_PM_ISO_FENCE0N_X2%A_c2 VSS N_A_M0_g 5.8277e-17
C_x_PM_ISO_FENCE0N_X2%A_c3 VSS N_A_M3_g 4.31368e-17
R_x_PM_ISO_FENCE0N_X2%A_r4 x_PM_ISO_FENCE0N_X2%A_18 x_PM_ISO_FENCE0N_X2%A_14 4.74714
R_x_PM_ISO_FENCE0N_X2%A_r5 x_PM_ISO_FENCE0N_X2%A_17 x_PM_ISO_FENCE0N_X2%A_14 4.74714
R_x_PM_ISO_FENCE0N_X2%A_r6 x_PM_ISO_FENCE0N_X2%A_14 x_PM_ISO_FENCE0N_X2%A_12 25.0012
R_x_PM_ISO_FENCE0N_X2%A_r7 x_PM_ISO_FENCE0N_X2%A_12 A 0.156071
R_x_PM_ISO_FENCE0N_X2%A_r8 N_A_M0_g x_PM_ISO_FENCE0N_X2%A_18 72.15
R_x_PM_ISO_FENCE0N_X2%A_r9 N_A_M3_g x_PM_ISO_FENCE0N_X2%A_17 39
C_x_PM_ISO_FENCE0N_X2%EN_c0 VSS x_PM_ISO_FENCE0N_X2%EN_14 8.80774e-18
C_x_PM_ISO_FENCE0N_X2%EN_c1 VSS x_PM_ISO_FENCE0N_X2%EN_12 7.44323e-17
C_x_PM_ISO_FENCE0N_X2%EN_c2 VSS N_EN_M1_g 6.50433e-17
C_x_PM_ISO_FENCE0N_X2%EN_c3 VSS N_EN_M4_g 4.31679e-17
R_x_PM_ISO_FENCE0N_X2%EN_r4 x_PM_ISO_FENCE0N_X2%EN_18 x_PM_ISO_FENCE0N_X2%EN_14 4.7687
R_x_PM_ISO_FENCE0N_X2%EN_r5 x_PM_ISO_FENCE0N_X2%EN_17 x_PM_ISO_FENCE0N_X2%EN_14 4.7687
R_x_PM_ISO_FENCE0N_X2%EN_r6 x_PM_ISO_FENCE0N_X2%EN_14 x_PM_ISO_FENCE0N_X2%EN_12 25.0012
R_x_PM_ISO_FENCE0N_X2%EN_r7 x_PM_ISO_FENCE0N_X2%EN_12 EN 0.169643
R_x_PM_ISO_FENCE0N_X2%EN_r8 N_EN_M1_g x_PM_ISO_FENCE0N_X2%EN_18 72.93
R_x_PM_ISO_FENCE0N_X2%EN_r9 N_EN_M4_g x_PM_ISO_FENCE0N_X2%EN_17 38.22
C_x_PM_ISO_FENCE0N_X2%Z_c0 VSS N_Z_M5_d 1.4069e-16
R_x_PM_ISO_FENCE0N_X2%Z_r1 N_Z_M2_d Z 1.10833
R_x_PM_ISO_FENCE0N_X2%Z_r2 Z N_Z_M5_d 1.045
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE0N_X4.                                                  *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:42 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE0N_X4 VDD VSS A EN Z
*.PININFO VDD:P VSS:G A:I EN:I Z:O
*.EQN Z=(A * EN)
M_M4 N_3_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M5 N_VDD_M1_d N_EN_M1_g N_3_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M6 N_Z_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M7 N_VDD_M3_d N_3_M3_g N_Z_M2_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M0 7 N_A_M4_g N_3_M4_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 N_VSS_M5_d N_EN_M5_g 7 VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_Z_M6_d N_3_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.305000U L=0.050000U
M_M3 N_VSS_M7_d N_3_M7_g N_Z_M6_d VSS NMOS_VTL W=0.305000U L=0.050000U
C_x_PM_ISO_FENCE0N_X4%VDD_c0 VSS x_PM_ISO_FENCE0N_X4%VDD_41 2.99637e-18
C_x_PM_ISO_FENCE0N_X4%VDD_c1 VSS x_PM_ISO_FENCE0N_X4%VDD_31 2.71473e-16
C_x_PM_ISO_FENCE0N_X4%VDD_c2 VSS N_VDD_M3_d 2.5536e-17
C_x_PM_ISO_FENCE0N_X4%VDD_c3 VSS x_PM_ISO_FENCE0N_X4%VDD_25 2.08323e-17
C_x_PM_ISO_FENCE0N_X4%VDD_c4 VSS N_VDD_M1_d 5.22989e-17
C_x_PM_ISO_FENCE0N_X4%VDD_c5 VSS x_PM_ISO_FENCE0N_X4%VDD_20 2.08555e-17
C_x_PM_ISO_FENCE0N_X4%VDD_c6 VSS x_PM_ISO_FENCE0N_X4%VDD_19 2.03395e-17
C_x_PM_ISO_FENCE0N_X4%VDD_c7 VSS N_VDD_M0_s 2.96629e-17
C_x_PM_ISO_FENCE0N_X4%VDD_c8 VSS x_PM_ISO_FENCE0N_X4%VDD_14 1.92462e-17
C_x_PM_ISO_FENCE0N_X4%VDD_c9 VSS x_PM_ISO_FENCE0N_X4%VDD_13 2.334e-16
C_x_PM_ISO_FENCE0N_X4%VDD_c10 VSS x_PM_ISO_FENCE0N_X4%VDD_10 5.90809e-16
R_x_PM_ISO_FENCE0N_X4%VDD_r11 VDD x_PM_ISO_FENCE0N_X4%VDD_42 0.436117
R_x_PM_ISO_FENCE0N_X4%VDD_r12 x_PM_ISO_FENCE0N_X4%VDD_40 VDD 0.446663
R_x_PM_ISO_FENCE0N_X4%VDD_r13 VDD x_PM_ISO_FENCE0N_X4%VDD_31 0.143697
R_x_PM_ISO_FENCE0N_X4%VDD_r14 VDD x_PM_ISO_FENCE0N_X4%VDD_31 3.84471
R_x_PM_ISO_FENCE0N_X4%VDD_r15 N_VDD_M3_d x_PM_ISO_FENCE0N_X4%VDD_42 0.665
R_x_PM_ISO_FENCE0N_X4%VDD_r16 x_PM_ISO_FENCE0N_X4%VDD_41 x_PM_ISO_FENCE0N_X4%VDD_26 0.073144
R_x_PM_ISO_FENCE0N_X4%VDD_r17 x_PM_ISO_FENCE0N_X4%VDD_42 x_PM_ISO_FENCE0N_X4%VDD_25 0.075389
R_x_PM_ISO_FENCE0N_X4%VDD_r18 x_PM_ISO_FENCE0N_X4%VDD_26 x_PM_ISO_FENCE0N_X4%VDD_25 0.692941
R_x_PM_ISO_FENCE0N_X4%VDD_r19 x_PM_ISO_FENCE0N_X4%VDD_41 x_PM_ISO_FENCE0N_X4%VDD_21 0.145286
R_x_PM_ISO_FENCE0N_X4%VDD_r20 N_VDD_M1_d x_PM_ISO_FENCE0N_X4%VDD_21 0.800714
R_x_PM_ISO_FENCE0N_X4%VDD_r21 x_PM_ISO_FENCE0N_X4%VDD_40 x_PM_ISO_FENCE0N_X4%VDD_20 0.075401
R_x_PM_ISO_FENCE0N_X4%VDD_r22 x_PM_ISO_FENCE0N_X4%VDD_41 x_PM_ISO_FENCE0N_X4%VDD_19 0.073144
R_x_PM_ISO_FENCE0N_X4%VDD_r23 x_PM_ISO_FENCE0N_X4%VDD_20 x_PM_ISO_FENCE0N_X4%VDD_19 0.681765
R_x_PM_ISO_FENCE0N_X4%VDD_r24 N_VDD_M0_s x_PM_ISO_FENCE0N_X4%VDD_40 0.800714
R_x_PM_ISO_FENCE0N_X4%VDD_r25 VDD x_PM_ISO_FENCE0N_X4%VDD_14 0.140282
R_x_PM_ISO_FENCE0N_X4%VDD_r26 VDD x_PM_ISO_FENCE0N_X4%VDD_13 0.143957
R_x_PM_ISO_FENCE0N_X4%VDD_r27 x_PM_ISO_FENCE0N_X4%VDD_14 x_PM_ISO_FENCE0N_X4%VDD_13 7.68941
R_x_PM_ISO_FENCE0N_X4%VDD_r28 VDD x_PM_ISO_FENCE0N_X4%VDD_10 9.15353
C_x_PM_ISO_FENCE0N_X4%VSS_c0 VSS x_PM_ISO_FENCE0N_X4%VSS_36 2.334e-16
C_x_PM_ISO_FENCE0N_X4%VSS_c1 VSS VSS 2.71327e-16
C_x_PM_ISO_FENCE0N_X4%VSS_c2 VSS N_VSS_M7_d 2.68306e-17
C_x_PM_ISO_FENCE0N_X4%VSS_c3 VSS x_PM_ISO_FENCE0N_X4%VSS_22 3.95242e-17
C_x_PM_ISO_FENCE0N_X4%VSS_c4 VSS N_VSS_M5_d 2.33722e-17
C_x_PM_ISO_FENCE0N_X4%VSS_c5 VSS VSS 2.68952e-18
C_x_PM_ISO_FENCE0N_X4%VSS_c6 VSS x_PM_ISO_FENCE0N_X4%VSS_15 1.07522e-17
C_x_PM_ISO_FENCE0N_X4%VSS_c7 VSS x_PM_ISO_FENCE0N_X4%VSS_14 4.82868e-17
C_x_PM_ISO_FENCE0N_X4%VSS_c8 VSS x_PM_ISO_FENCE0N_X4%VSS_11 5.90809e-16
C_x_PM_ISO_FENCE0N_X4%VSS_c9 VSS x_PM_ISO_FENCE0N_X4%VSS_10 1.92462e-17
R_x_PM_ISO_FENCE0N_X4%VSS_r10 VSS x_PM_ISO_FENCE0N_X4%VSS_39 0.436117
R_x_PM_ISO_FENCE0N_X4%VSS_r11 x_PM_ISO_FENCE0N_X4%VSS_36 VSS 0.138985
R_x_PM_ISO_FENCE0N_X4%VSS_r12 N_VSS_M7_d x_PM_ISO_FENCE0N_X4%VSS_39 1.01786
R_x_PM_ISO_FENCE0N_X4%VSS_r13 x_PM_ISO_FENCE0N_X4%VSS_39 x_PM_ISO_FENCE0N_X4%VSS_22 0.075389
R_x_PM_ISO_FENCE0N_X4%VSS_r14 x_PM_ISO_FENCE0N_X4%VSS_23 x_PM_ISO_FENCE0N_X4%VSS_22 0.692941
R_x_PM_ISO_FENCE0N_X4%VSS_r15 N_VSS_M5_d VSS 0.257857
R_x_PM_ISO_FENCE0N_X4%VSS_r16 VSS x_PM_ISO_FENCE0N_X4%VSS_23 0.073144
R_x_PM_ISO_FENCE0N_X4%VSS_r17 x_PM_ISO_FENCE0N_X4%VSS_15 VSS 0.138595
R_x_PM_ISO_FENCE0N_X4%VSS_r18 VSS x_PM_ISO_FENCE0N_X4%VSS_14 0.073144
R_x_PM_ISO_FENCE0N_X4%VSS_r19 x_PM_ISO_FENCE0N_X4%VSS_15 x_PM_ISO_FENCE0N_X4%VSS_14 1.08412
R_x_PM_ISO_FENCE0N_X4%VSS_r20 VSS x_PM_ISO_FENCE0N_X4%VSS_11 9.15353
R_x_PM_ISO_FENCE0N_X4%VSS_r21 VSS x_PM_ISO_FENCE0N_X4%VSS_10 0.140282
R_x_PM_ISO_FENCE0N_X4%VSS_r22 x_PM_ISO_FENCE0N_X4%VSS_10 x_PM_ISO_FENCE0N_X4%VSS_36 7.68941
C_x_PM_ISO_FENCE0N_X4%3_c0 VSS x_PM_ISO_FENCE0N_X4%3_35 1.12929e-16
C_x_PM_ISO_FENCE0N_X4%3_c1 VSS x_PM_ISO_FENCE0N_X4%3_31 1.20429e-17
C_x_PM_ISO_FENCE0N_X4%3_c2 VSS x_PM_ISO_FENCE0N_X4%3_30 4.23554e-17
C_x_PM_ISO_FENCE0N_X4%3_c3 VSS N_3_M0_d 3.52734e-17
C_x_PM_ISO_FENCE0N_X4%3_c4 VSS x_PM_ISO_FENCE0N_X4%3_22 7.42936e-17
C_x_PM_ISO_FENCE0N_X4%3_c5 VSS x_PM_ISO_FENCE0N_X4%3_19 3.30952e-18
C_x_PM_ISO_FENCE0N_X4%3_c6 VSS N_3_M3_g 4.42329e-17
C_x_PM_ISO_FENCE0N_X4%3_c7 VSS N_3_M7_g 4.62699e-17
C_x_PM_ISO_FENCE0N_X4%3_c8 VSS x_PM_ISO_FENCE0N_X4%3_10 8.06468e-18
C_x_PM_ISO_FENCE0N_X4%3_c9 VSS x_PM_ISO_FENCE0N_X4%3_9 1.21687e-17
C_x_PM_ISO_FENCE0N_X4%3_c10 VSS N_3_M2_g 4.0601e-17
C_x_PM_ISO_FENCE0N_X4%3_c11 VSS N_3_M6_g 4.08072e-17
R_x_PM_ISO_FENCE0N_X4%3_r12 x_PM_ISO_FENCE0N_X4%3_39 x_PM_ISO_FENCE0N_X4%3_37 4.94
R_x_PM_ISO_FENCE0N_X4%3_r13 x_PM_ISO_FENCE0N_X4%3_37 x_PM_ISO_FENCE0N_X4%3_35 25.0012
R_x_PM_ISO_FENCE0N_X4%3_r14 x_PM_ISO_FENCE0N_X4%3_35 x_PM_ISO_FENCE0N_X4%3_33 0.855
R_x_PM_ISO_FENCE0N_X4%3_r15 x_PM_ISO_FENCE0N_X4%3_35 x_PM_ISO_FENCE0N_X4%3_32 1.69643
R_x_PM_ISO_FENCE0N_X4%3_r16 x_PM_ISO_FENCE0N_X4%3_33 x_PM_ISO_FENCE0N_X4%3_30 0.212317
R_x_PM_ISO_FENCE0N_X4%3_r17 x_PM_ISO_FENCE0N_X4%3_31 x_PM_ISO_FENCE0N_X4%3_30 0.868571
R_x_PM_ISO_FENCE0N_X4%3_r18 x_PM_ISO_FENCE0N_X4%3_31 x_PM_ISO_FENCE0N_X4%3_26 0.212317
R_x_PM_ISO_FENCE0N_X4%3_r19 N_3_M0_d x_PM_ISO_FENCE0N_X4%3_26 0.746429
R_x_PM_ISO_FENCE0N_X4%3_r20 x_PM_ISO_FENCE0N_X4%3_32 x_PM_ISO_FENCE0N_X4%3_22 0.212317
R_x_PM_ISO_FENCE0N_X4%3_r21 N_3_M4_s x_PM_ISO_FENCE0N_X4%3_22 2.10357
R_x_PM_ISO_FENCE0N_X4%3_r22 x_PM_ISO_FENCE0N_X4%3_19 x_PM_ISO_FENCE0N_X4%3_15 4.56151
R_x_PM_ISO_FENCE0N_X4%3_r23 N_3_M3_g x_PM_ISO_FENCE0N_X4%3_15 49.53
R_x_PM_ISO_FENCE0N_X4%3_r24 x_PM_ISO_FENCE0N_X4%3_19 x_PM_ISO_FENCE0N_X4%3_11 4.56151
R_x_PM_ISO_FENCE0N_X4%3_r25 N_3_M7_g x_PM_ISO_FENCE0N_X4%3_11 59.67
R_x_PM_ISO_FENCE0N_X4%3_r26 x_PM_ISO_FENCE0N_X4%3_39 x_PM_ISO_FENCE0N_X4%3_10 2.6
R_x_PM_ISO_FENCE0N_X4%3_r27 x_PM_ISO_FENCE0N_X4%3_19 x_PM_ISO_FENCE0N_X4%3_9 0.043368
R_x_PM_ISO_FENCE0N_X4%3_r28 x_PM_ISO_FENCE0N_X4%3_10 x_PM_ISO_FENCE0N_X4%3_9 14.56
R_x_PM_ISO_FENCE0N_X4%3_r29 x_PM_ISO_FENCE0N_X4%3_39 x_PM_ISO_FENCE0N_X4%3_5 1.95
R_x_PM_ISO_FENCE0N_X4%3_r30 N_3_M2_g x_PM_ISO_FENCE0N_X4%3_5 49.53
R_x_PM_ISO_FENCE0N_X4%3_r31 x_PM_ISO_FENCE0N_X4%3_39 x_PM_ISO_FENCE0N_X4%3_1 1.95
R_x_PM_ISO_FENCE0N_X4%3_r32 N_3_M6_g x_PM_ISO_FENCE0N_X4%3_1 59.67
C_x_PM_ISO_FENCE0N_X4%A_c0 VSS x_PM_ISO_FENCE0N_X4%A_18 9.19188e-18
C_x_PM_ISO_FENCE0N_X4%A_c1 VSS x_PM_ISO_FENCE0N_X4%A_12 3.91953e-17
C_x_PM_ISO_FENCE0N_X4%A_c2 VSS N_A_M0_g 6.03881e-17
C_x_PM_ISO_FENCE0N_X4%A_c3 VSS N_A_M4_g 5.4076e-17
R_x_PM_ISO_FENCE0N_X4%A_r4 x_PM_ISO_FENCE0N_X4%A_18 x_PM_ISO_FENCE0N_X4%A_14 4.42
R_x_PM_ISO_FENCE0N_X4%A_r5 x_PM_ISO_FENCE0N_X4%A_14 x_PM_ISO_FENCE0N_X4%A_12 25.0012
R_x_PM_ISO_FENCE0N_X4%A_r6 x_PM_ISO_FENCE0N_X4%A_12 A 0.156071
R_x_PM_ISO_FENCE0N_X4%A_r7 x_PM_ISO_FENCE0N_X4%A_18 x_PM_ISO_FENCE0N_X4%A_5 1.95
R_x_PM_ISO_FENCE0N_X4%A_r8 N_A_M0_g x_PM_ISO_FENCE0N_X4%A_5 53.04
R_x_PM_ISO_FENCE0N_X4%A_r9 x_PM_ISO_FENCE0N_X4%A_18 x_PM_ISO_FENCE0N_X4%A_1 1.95
R_x_PM_ISO_FENCE0N_X4%A_r10 N_A_M4_g x_PM_ISO_FENCE0N_X4%A_1 51.48
C_x_PM_ISO_FENCE0N_X4%EN_c0 VSS x_PM_ISO_FENCE0N_X4%EN_14 8.95588e-18
C_x_PM_ISO_FENCE0N_X4%EN_c1 VSS x_PM_ISO_FENCE0N_X4%EN_12 6.45485e-17
C_x_PM_ISO_FENCE0N_X4%EN_c2 VSS N_EN_M1_g 6.24395e-17
C_x_PM_ISO_FENCE0N_X4%EN_c3 VSS N_EN_M5_g 5.82741e-17
R_x_PM_ISO_FENCE0N_X4%EN_r4 x_PM_ISO_FENCE0N_X4%EN_18 x_PM_ISO_FENCE0N_X4%EN_14 4.7687
R_x_PM_ISO_FENCE0N_X4%EN_r5 x_PM_ISO_FENCE0N_X4%EN_17 x_PM_ISO_FENCE0N_X4%EN_14 4.7687
R_x_PM_ISO_FENCE0N_X4%EN_r6 x_PM_ISO_FENCE0N_X4%EN_14 x_PM_ISO_FENCE0N_X4%EN_12 25.0012
R_x_PM_ISO_FENCE0N_X4%EN_r7 x_PM_ISO_FENCE0N_X4%EN_12 EN 0.2375
R_x_PM_ISO_FENCE0N_X4%EN_r8 N_EN_M1_g x_PM_ISO_FENCE0N_X4%EN_18 53.04
R_x_PM_ISO_FENCE0N_X4%EN_r9 N_EN_M5_g x_PM_ISO_FENCE0N_X4%EN_17 51.48
C_x_PM_ISO_FENCE0N_X4%Z_c0 VSS N_Z_M6_d 2.06047e-16
R_x_PM_ISO_FENCE0N_X4%Z_r1 N_Z_M2_d Z 2.13071
R_x_PM_ISO_FENCE0N_X4%Z_r2 Z N_Z_M6_d 1.47929
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE0_X1.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE0_X1 VDD VSS EN Z A
*.PININFO VDD:P VSS:G EN:I Z:O A:I
*.EQN Z=!(A + EN)
M_M2 6 N_EN_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.250000U L=0.050000U
M_M3 N_Z_M1_d N_A_M1_g 6 VDD PMOS_VTL W=0.250000U L=0.050000U
M_M0 N_Z_M2_d N_EN_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.155000U L=0.050000U
M_M1 N_VSS_M3_d N_A_M3_g N_Z_M2_d VSS NMOS_VTL W=0.155000U L=0.050000U
C_x_PM_ISO_FENCE0_X1%VDD_c0 VSS x_PM_ISO_FENCE0_X1%VDD_31 4.19174e-17
C_x_PM_ISO_FENCE0_X1%VDD_c1 VSS x_PM_ISO_FENCE0_X1%VDD_19 2.61735e-16
C_x_PM_ISO_FENCE0_X1%VDD_c2 VSS x_PM_ISO_FENCE0_X1%VDD_18 1.89914e-17
C_x_PM_ISO_FENCE0_X1%VDD_c3 VSS N_VDD_M0_s 1.30423e-17
C_x_PM_ISO_FENCE0_X1%VDD_c4 VSS x_PM_ISO_FENCE0_X1%VDD_12 1.92462e-17
C_x_PM_ISO_FENCE0_X1%VDD_c5 VSS x_PM_ISO_FENCE0_X1%VDD_11 2.334e-16
C_x_PM_ISO_FENCE0_X1%VDD_c6 VSS x_PM_ISO_FENCE0_X1%VDD_8 5.65101e-16
R_x_PM_ISO_FENCE0_X1%VDD_r7 x_PM_ISO_FENCE0_X1%VDD_31 VDD 0.13879
R_x_PM_ISO_FENCE0_X1%VDD_r8 x_PM_ISO_FENCE0_X1%VDD_28 VDD 0.392137
R_x_PM_ISO_FENCE0_X1%VDD_r9 x_PM_ISO_FENCE0_X1%VDD_19 VDD 0.13879
R_x_PM_ISO_FENCE0_X1%VDD_r10 VDD x_PM_ISO_FENCE0_X1%VDD_19 3.84471
R_x_PM_ISO_FENCE0_X1%VDD_r11 x_PM_ISO_FENCE0_X1%VDD_28 x_PM_ISO_FENCE0_X1%VDD_18 0.0753
R_x_PM_ISO_FENCE0_X1%VDD_r12 x_PM_ISO_FENCE0_X1%VDD_18 x_PM_ISO_FENCE0_X1%VDD_31 1.12882
R_x_PM_ISO_FENCE0_X1%VDD_r13 N_VDD_M0_s x_PM_ISO_FENCE0_X1%VDD_28 0.339286
R_x_PM_ISO_FENCE0_X1%VDD_r14 VDD x_PM_ISO_FENCE0_X1%VDD_12 0.140282
R_x_PM_ISO_FENCE0_X1%VDD_r15 VDD x_PM_ISO_FENCE0_X1%VDD_11 0.143516
R_x_PM_ISO_FENCE0_X1%VDD_r16 x_PM_ISO_FENCE0_X1%VDD_12 x_PM_ISO_FENCE0_X1%VDD_11 7.68941
R_x_PM_ISO_FENCE0_X1%VDD_r17 VDD x_PM_ISO_FENCE0_X1%VDD_8 8.72882
C_x_PM_ISO_FENCE0_X1%VSS_c0 VSS VSS 2.73208e-16
C_x_PM_ISO_FENCE0_X1%VSS_c1 VSS N_VSS_M3_d 1.65239e-17
C_x_PM_ISO_FENCE0_X1%VSS_c2 VSS x_PM_ISO_FENCE0_X1%VSS_19 1.90806e-17
C_x_PM_ISO_FENCE0_X1%VSS_c3 VSS x_PM_ISO_FENCE0_X1%VSS_18 2.47267e-17
C_x_PM_ISO_FENCE0_X1%VSS_c4 VSS N_VSS_M2_s 1.39499e-17
C_x_PM_ISO_FENCE0_X1%VSS_c5 VSS x_PM_ISO_FENCE0_X1%VSS_11 5.65101e-16
C_x_PM_ISO_FENCE0_X1%VSS_c6 VSS x_PM_ISO_FENCE0_X1%VSS_10 1.92462e-17
C_x_PM_ISO_FENCE0_X1%VSS_c7 VSS x_PM_ISO_FENCE0_X1%VSS_9 2.334e-16
R_x_PM_ISO_FENCE0_X1%VSS_r8 VSS x_PM_ISO_FENCE0_X1%VSS_35 0.490833
R_x_PM_ISO_FENCE0_X1%VSS_r9 x_PM_ISO_FENCE0_X1%VSS_34 VSS 0.392137
R_x_PM_ISO_FENCE0_X1%VSS_r10 N_VSS_M3_d x_PM_ISO_FENCE0_X1%VSS_35 0.556429
R_x_PM_ISO_FENCE0_X1%VSS_r11 x_PM_ISO_FENCE0_X1%VSS_34 x_PM_ISO_FENCE0_X1%VSS_19 0.0753
R_x_PM_ISO_FENCE0_X1%VSS_r12 VSS x_PM_ISO_FENCE0_X1%VSS_19 0.391176
R_x_PM_ISO_FENCE0_X1%VSS_r13 x_PM_ISO_FENCE0_X1%VSS_35 x_PM_ISO_FENCE0_X1%VSS_18 0.075492
R_x_PM_ISO_FENCE0_X1%VSS_r14 VSS x_PM_ISO_FENCE0_X1%VSS_18 0.290588
R_x_PM_ISO_FENCE0_X1%VSS_r15 N_VSS_M2_s x_PM_ISO_FENCE0_X1%VSS_34 0.556429
R_x_PM_ISO_FENCE0_X1%VSS_r16 VSS x_PM_ISO_FENCE0_X1%VSS_11 8.72882
R_x_PM_ISO_FENCE0_X1%VSS_r17 VSS x_PM_ISO_FENCE0_X1%VSS_10 0.140282
R_x_PM_ISO_FENCE0_X1%VSS_r18 VSS x_PM_ISO_FENCE0_X1%VSS_9 0.143516
R_x_PM_ISO_FENCE0_X1%VSS_r19 x_PM_ISO_FENCE0_X1%VSS_10 x_PM_ISO_FENCE0_X1%VSS_9 7.68941
C_x_PM_ISO_FENCE0_X1%EN_c0 VSS x_PM_ISO_FENCE0_X1%EN_14 7.54905e-18
C_x_PM_ISO_FENCE0_X1%EN_c1 VSS x_PM_ISO_FENCE0_X1%EN_12 3.46394e-17
C_x_PM_ISO_FENCE0_X1%EN_c2 VSS N_EN_M0_g 5.17077e-17
C_x_PM_ISO_FENCE0_X1%EN_c3 VSS N_EN_M2_g 6.02359e-17
R_x_PM_ISO_FENCE0_X1%EN_r4 x_PM_ISO_FENCE0_X1%EN_18 x_PM_ISO_FENCE0_X1%EN_14 4.74714
R_x_PM_ISO_FENCE0_X1%EN_r5 x_PM_ISO_FENCE0_X1%EN_17 x_PM_ISO_FENCE0_X1%EN_14 4.74714
R_x_PM_ISO_FENCE0_X1%EN_r6 x_PM_ISO_FENCE0_X1%EN_14 x_PM_ISO_FENCE0_X1%EN_12 25.0012
R_x_PM_ISO_FENCE0_X1%EN_r7 x_PM_ISO_FENCE0_X1%EN_12 EN 0.156071
R_x_PM_ISO_FENCE0_X1%EN_r8 N_EN_M0_g x_PM_ISO_FENCE0_X1%EN_18 56.16
R_x_PM_ISO_FENCE0_X1%EN_r9 N_EN_M2_g x_PM_ISO_FENCE0_X1%EN_17 78.39
C_x_PM_ISO_FENCE0_X1%Z_c0 VSS N_Z_M1_d 7.19916e-17
C_x_PM_ISO_FENCE0_X1%Z_c1 VSS x_PM_ISO_FENCE0_X1%Z_9 1.70333e-17
C_x_PM_ISO_FENCE0_X1%Z_c2 VSS Z 1.19444e-17
C_x_PM_ISO_FENCE0_X1%Z_c3 VSS N_Z_M2_d 5.10579e-17
R_x_PM_ISO_FENCE0_X1%Z_r4 N_Z_M1_d x_PM_ISO_FENCE0_X1%Z_11 2.622
R_x_PM_ISO_FENCE0_X1%Z_r5 x_PM_ISO_FENCE0_X1%Z_11 x_PM_ISO_FENCE0_X1%Z_9 0.212645
R_x_PM_ISO_FENCE0_X1%Z_r6 x_PM_ISO_FENCE0_X1%Z_10 x_PM_ISO_FENCE0_X1%Z_9 0.542857
R_x_PM_ISO_FENCE0_X1%Z_r7 x_PM_ISO_FENCE0_X1%Z_10 Z 0.194115
R_x_PM_ISO_FENCE0_X1%Z_r8 Z N_Z_M2_d 0.994259
C_x_PM_ISO_FENCE0_X1%A_c0 VSS x_PM_ISO_FENCE0_X1%A_18 1.30521e-17
C_x_PM_ISO_FENCE0_X1%A_c1 VSS x_PM_ISO_FENCE0_X1%A_12 5.63569e-17
C_x_PM_ISO_FENCE0_X1%A_c2 VSS N_A_M1_g 5.84327e-17
C_x_PM_ISO_FENCE0_X1%A_c3 VSS N_A_M3_g 6.99739e-17
R_x_PM_ISO_FENCE0_X1%A_r4 x_PM_ISO_FENCE0_X1%A_18 x_PM_ISO_FENCE0_X1%A_14 4.42
R_x_PM_ISO_FENCE0_X1%A_r5 x_PM_ISO_FENCE0_X1%A_14 x_PM_ISO_FENCE0_X1%A_12 25.0012
R_x_PM_ISO_FENCE0_X1%A_r6 x_PM_ISO_FENCE0_X1%A_12 A 0.088214
R_x_PM_ISO_FENCE0_X1%A_r7 x_PM_ISO_FENCE0_X1%A_18 x_PM_ISO_FENCE0_X1%A_5 1.95
R_x_PM_ISO_FENCE0_X1%A_r8 N_A_M1_g x_PM_ISO_FENCE0_X1%A_5 56.16
R_x_PM_ISO_FENCE0_X1%A_r9 x_PM_ISO_FENCE0_X1%A_18 x_PM_ISO_FENCE0_X1%A_1 1.95
R_x_PM_ISO_FENCE0_X1%A_r10 N_A_M3_g x_PM_ISO_FENCE0_X1%A_1 78.39
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE0_X2.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE0_X2 VDD VSS EN Z A
*.PININFO VDD:P VSS:G EN:I Z:O A:I
*.EQN Z=!(A + EN)
M_M2 6 N_EN_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.505000U L=0.050000U
M_M3 N_Z_M1_d N_A_M1_g 6 VDD PMOS_VTL W=0.505000U L=0.050000U
M_M0 N_Z_M2_d N_EN_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.305000U L=0.050000U
M_M1 N_VSS_M3_d N_A_M3_g N_Z_M2_d VSS NMOS_VTL W=0.305000U L=0.050000U
C_x_PM_ISO_FENCE0_X2%VDD_c0 VSS x_PM_ISO_FENCE0_X2%VDD_31 3.89108e-17
C_x_PM_ISO_FENCE0_X2%VDD_c1 VSS x_PM_ISO_FENCE0_X2%VDD_19 2.61735e-16
C_x_PM_ISO_FENCE0_X2%VDD_c2 VSS x_PM_ISO_FENCE0_X2%VDD_18 1.91108e-17
C_x_PM_ISO_FENCE0_X2%VDD_c3 VSS N_VDD_M0_s 2.71619e-17
C_x_PM_ISO_FENCE0_X2%VDD_c4 VSS x_PM_ISO_FENCE0_X2%VDD_12 1.92462e-17
C_x_PM_ISO_FENCE0_X2%VDD_c5 VSS x_PM_ISO_FENCE0_X2%VDD_11 2.334e-16
C_x_PM_ISO_FENCE0_X2%VDD_c6 VSS x_PM_ISO_FENCE0_X2%VDD_8 5.65101e-16
R_x_PM_ISO_FENCE0_X2%VDD_r7 x_PM_ISO_FENCE0_X2%VDD_31 VDD 0.13879
R_x_PM_ISO_FENCE0_X2%VDD_r8 x_PM_ISO_FENCE0_X2%VDD_28 VDD 0.392137
R_x_PM_ISO_FENCE0_X2%VDD_r9 x_PM_ISO_FENCE0_X2%VDD_19 VDD 0.13879
R_x_PM_ISO_FENCE0_X2%VDD_r10 VDD x_PM_ISO_FENCE0_X2%VDD_19 3.84471
R_x_PM_ISO_FENCE0_X2%VDD_r11 x_PM_ISO_FENCE0_X2%VDD_28 x_PM_ISO_FENCE0_X2%VDD_18 0.0753
R_x_PM_ISO_FENCE0_X2%VDD_r12 x_PM_ISO_FENCE0_X2%VDD_18 x_PM_ISO_FENCE0_X2%VDD_31 1.12882
R_x_PM_ISO_FENCE0_X2%VDD_r13 N_VDD_M0_s x_PM_ISO_FENCE0_X2%VDD_28 0.420714
R_x_PM_ISO_FENCE0_X2%VDD_r14 VDD x_PM_ISO_FENCE0_X2%VDD_12 0.140282
R_x_PM_ISO_FENCE0_X2%VDD_r15 VDD x_PM_ISO_FENCE0_X2%VDD_11 0.143516
R_x_PM_ISO_FENCE0_X2%VDD_r16 x_PM_ISO_FENCE0_X2%VDD_12 x_PM_ISO_FENCE0_X2%VDD_11 7.68941
R_x_PM_ISO_FENCE0_X2%VDD_r17 VDD x_PM_ISO_FENCE0_X2%VDD_8 8.72882
C_x_PM_ISO_FENCE0_X2%VSS_c0 VSS VSS 2.73263e-16
C_x_PM_ISO_FENCE0_X2%VSS_c1 VSS N_VSS_M3_d 3.7727e-17
C_x_PM_ISO_FENCE0_X2%VSS_c2 VSS x_PM_ISO_FENCE0_X2%VSS_19 1.89637e-17
C_x_PM_ISO_FENCE0_X2%VSS_c3 VSS x_PM_ISO_FENCE0_X2%VSS_18 3.56797e-17
C_x_PM_ISO_FENCE0_X2%VSS_c4 VSS N_VSS_M2_s 2.74633e-17
C_x_PM_ISO_FENCE0_X2%VSS_c5 VSS x_PM_ISO_FENCE0_X2%VSS_11 5.65101e-16
C_x_PM_ISO_FENCE0_X2%VSS_c6 VSS x_PM_ISO_FENCE0_X2%VSS_10 1.92462e-17
C_x_PM_ISO_FENCE0_X2%VSS_c7 VSS x_PM_ISO_FENCE0_X2%VSS_9 2.334e-16
R_x_PM_ISO_FENCE0_X2%VSS_r8 VSS x_PM_ISO_FENCE0_X2%VSS_35 0.490833
R_x_PM_ISO_FENCE0_X2%VSS_r9 x_PM_ISO_FENCE0_X2%VSS_34 VSS 0.392137
R_x_PM_ISO_FENCE0_X2%VSS_r10 N_VSS_M3_d x_PM_ISO_FENCE0_X2%VSS_35 0.990714
R_x_PM_ISO_FENCE0_X2%VSS_r11 x_PM_ISO_FENCE0_X2%VSS_34 x_PM_ISO_FENCE0_X2%VSS_19 0.0753
R_x_PM_ISO_FENCE0_X2%VSS_r12 VSS x_PM_ISO_FENCE0_X2%VSS_19 0.391176
R_x_PM_ISO_FENCE0_X2%VSS_r13 x_PM_ISO_FENCE0_X2%VSS_35 x_PM_ISO_FENCE0_X2%VSS_18 0.075492
R_x_PM_ISO_FENCE0_X2%VSS_r14 VSS x_PM_ISO_FENCE0_X2%VSS_18 0.290588
R_x_PM_ISO_FENCE0_X2%VSS_r15 N_VSS_M2_s x_PM_ISO_FENCE0_X2%VSS_34 0.990714
R_x_PM_ISO_FENCE0_X2%VSS_r16 VSS x_PM_ISO_FENCE0_X2%VSS_11 8.72882
R_x_PM_ISO_FENCE0_X2%VSS_r17 VSS x_PM_ISO_FENCE0_X2%VSS_10 0.140282
R_x_PM_ISO_FENCE0_X2%VSS_r18 VSS x_PM_ISO_FENCE0_X2%VSS_9 0.143516
R_x_PM_ISO_FENCE0_X2%VSS_r19 x_PM_ISO_FENCE0_X2%VSS_10 x_PM_ISO_FENCE0_X2%VSS_9 7.68941
C_x_PM_ISO_FENCE0_X2%EN_c0 VSS x_PM_ISO_FENCE0_X2%EN_14 7.10082e-18
C_x_PM_ISO_FENCE0_X2%EN_c1 VSS x_PM_ISO_FENCE0_X2%EN_12 3.2934e-17
C_x_PM_ISO_FENCE0_X2%EN_c2 VSS N_EN_M0_g 6.6368e-17
C_x_PM_ISO_FENCE0_X2%EN_c3 VSS N_EN_M2_g 5.73769e-17
R_x_PM_ISO_FENCE0_X2%EN_r4 x_PM_ISO_FENCE0_X2%EN_18 x_PM_ISO_FENCE0_X2%EN_14 4.7687
R_x_PM_ISO_FENCE0_X2%EN_r5 x_PM_ISO_FENCE0_X2%EN_17 x_PM_ISO_FENCE0_X2%EN_14 4.7687
R_x_PM_ISO_FENCE0_X2%EN_r6 x_PM_ISO_FENCE0_X2%EN_14 x_PM_ISO_FENCE0_X2%EN_12 25.0012
R_x_PM_ISO_FENCE0_X2%EN_r7 x_PM_ISO_FENCE0_X2%EN_12 EN 0.169643
R_x_PM_ISO_FENCE0_X2%EN_r8 N_EN_M0_g x_PM_ISO_FENCE0_X2%EN_18 55.77
R_x_PM_ISO_FENCE0_X2%EN_r9 N_EN_M2_g x_PM_ISO_FENCE0_X2%EN_17 54.21
C_x_PM_ISO_FENCE0_X2%Z_c0 VSS Z 7.00301e-17
C_x_PM_ISO_FENCE0_X2%Z_c1 VSS x_PM_ISO_FENCE0_X2%Z_8 1.3853e-17
C_x_PM_ISO_FENCE0_X2%Z_c2 VSS x_PM_ISO_FENCE0_X2%Z_7 3.36701e-17
C_x_PM_ISO_FENCE0_X2%Z_c3 VSS N_Z_M2_d 5.82533e-17
R_x_PM_ISO_FENCE0_X2%Z_r4 N_Z_M1_d Z 1.93167
R_x_PM_ISO_FENCE0_X2%Z_r5 Z x_PM_ISO_FENCE0_X2%Z_9 0.021111
R_x_PM_ISO_FENCE0_X2%Z_r6 x_PM_ISO_FENCE0_X2%Z_9 x_PM_ISO_FENCE0_X2%Z_7 0.21666
R_x_PM_ISO_FENCE0_X2%Z_r7 x_PM_ISO_FENCE0_X2%Z_8 x_PM_ISO_FENCE0_X2%Z_7 0.651429
R_x_PM_ISO_FENCE0_X2%Z_r8 x_PM_ISO_FENCE0_X2%Z_8 x_PM_ISO_FENCE0_X2%Z_3 0.212317
R_x_PM_ISO_FENCE0_X2%Z_r9 N_Z_M2_d x_PM_ISO_FENCE0_X2%Z_3 0.312143
C_x_PM_ISO_FENCE0_X2%A_c0 VSS x_PM_ISO_FENCE0_X2%A_18 1.26691e-17
C_x_PM_ISO_FENCE0_X2%A_c1 VSS x_PM_ISO_FENCE0_X2%A_12 6.30962e-17
C_x_PM_ISO_FENCE0_X2%A_c2 VSS N_A_M1_g 6.88391e-17
C_x_PM_ISO_FENCE0_X2%A_c3 VSS N_A_M3_g 6.51679e-17
R_x_PM_ISO_FENCE0_X2%A_r4 x_PM_ISO_FENCE0_X2%A_18 x_PM_ISO_FENCE0_X2%A_14 3.9
R_x_PM_ISO_FENCE0_X2%A_r5 x_PM_ISO_FENCE0_X2%A_14 x_PM_ISO_FENCE0_X2%A_12 25.0012
R_x_PM_ISO_FENCE0_X2%A_r6 x_PM_ISO_FENCE0_X2%A_12 A 0.101786
R_x_PM_ISO_FENCE0_X2%A_r7 x_PM_ISO_FENCE0_X2%A_18 x_PM_ISO_FENCE0_X2%A_5 1.95
R_x_PM_ISO_FENCE0_X2%A_r8 N_A_M1_g x_PM_ISO_FENCE0_X2%A_5 55.77
R_x_PM_ISO_FENCE0_X2%A_r9 x_PM_ISO_FENCE0_X2%A_18 x_PM_ISO_FENCE0_X2%A_1 1.95
R_x_PM_ISO_FENCE0_X2%A_r10 N_A_M3_g x_PM_ISO_FENCE0_X2%A_1 54.21
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE0_X4.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE0_X4 VDD VSS EN Z A
*.PININFO VDD:P VSS:G EN:I Z:O A:I
*.EQN Z=!(A + EN)
M_M4 6 N_EN_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.505000U L=0.050000U
M_M5 N_Z_M1_d N_A_M1_g 6 VDD PMOS_VTL W=0.505000U L=0.050000U
M_M6 7 N_A_M2_g N_Z_M1_d VDD PMOS_VTL W=0.505000U L=0.050000U
M_M7 N_VDD_M3_d N_EN_M3_g 7 VDD PMOS_VTL W=0.505000U L=0.050000U
M_M0 N_Z_M4_d N_EN_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.305000U L=0.050000U
M_M1 N_VSS_M5_d N_A_M5_g N_Z_M4_d VSS NMOS_VTL W=0.305000U L=0.050000U
M_M2 N_Z_M6_d N_A_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.305000U L=0.050000U
M_M3 N_VSS_M7_d N_EN_M7_g N_Z_M6_d VSS NMOS_VTL W=0.305000U L=0.050000U
C_x_PM_ISO_FENCE0_X4%VDD_c0 VSS x_PM_ISO_FENCE0_X4%VDD_24 2.71617e-16
C_x_PM_ISO_FENCE0_X4%VDD_c1 VSS N_VDD_M3_d 1.23693e-17
C_x_PM_ISO_FENCE0_X4%VDD_c2 VSS x_PM_ISO_FENCE0_X4%VDD_19 1.99486e-17
C_x_PM_ISO_FENCE0_X4%VDD_c3 VSS x_PM_ISO_FENCE0_X4%VDD_18 6.21105e-17
C_x_PM_ISO_FENCE0_X4%VDD_c4 VSS N_VDD_M0_s 1.19246e-17
C_x_PM_ISO_FENCE0_X4%VDD_c5 VSS x_PM_ISO_FENCE0_X4%VDD_13 1.92462e-17
C_x_PM_ISO_FENCE0_X4%VDD_c6 VSS x_PM_ISO_FENCE0_X4%VDD_12 2.334e-16
C_x_PM_ISO_FENCE0_X4%VDD_c7 VSS x_PM_ISO_FENCE0_X4%VDD_9 5.90809e-16
R_x_PM_ISO_FENCE0_X4%VDD_r8 VDD x_PM_ISO_FENCE0_X4%VDD_34 0.446873
R_x_PM_ISO_FENCE0_X4%VDD_r9 x_PM_ISO_FENCE0_X4%VDD_33 VDD 0.424928
R_x_PM_ISO_FENCE0_X4%VDD_r10 VDD x_PM_ISO_FENCE0_X4%VDD_24 0.143746
R_x_PM_ISO_FENCE0_X4%VDD_r11 VDD x_PM_ISO_FENCE0_X4%VDD_24 3.84471
R_x_PM_ISO_FENCE0_X4%VDD_r12 N_VDD_M3_d x_PM_ISO_FENCE0_X4%VDD_34 0.366429
R_x_PM_ISO_FENCE0_X4%VDD_r13 x_PM_ISO_FENCE0_X4%VDD_33 x_PM_ISO_FENCE0_X4%VDD_19 0.075366
R_x_PM_ISO_FENCE0_X4%VDD_r14 x_PM_ISO_FENCE0_X4%VDD_34 x_PM_ISO_FENCE0_X4%VDD_18 0.075401
R_x_PM_ISO_FENCE0_X4%VDD_r15 x_PM_ISO_FENCE0_X4%VDD_19 x_PM_ISO_FENCE0_X4%VDD_18 1.54235
R_x_PM_ISO_FENCE0_X4%VDD_r16 N_VDD_M0_s x_PM_ISO_FENCE0_X4%VDD_33 0.366429
R_x_PM_ISO_FENCE0_X4%VDD_r17 VDD x_PM_ISO_FENCE0_X4%VDD_13 0.140282
R_x_PM_ISO_FENCE0_X4%VDD_r18 VDD x_PM_ISO_FENCE0_X4%VDD_12 0.143808
R_x_PM_ISO_FENCE0_X4%VDD_r19 x_PM_ISO_FENCE0_X4%VDD_13 x_PM_ISO_FENCE0_X4%VDD_12 7.68941
R_x_PM_ISO_FENCE0_X4%VDD_r20 VDD x_PM_ISO_FENCE0_X4%VDD_9 9.15353
C_x_PM_ISO_FENCE0_X4%VSS_c0 VSS VSS 2.72107e-16
C_x_PM_ISO_FENCE0_X4%VSS_c1 VSS N_VSS_M7_d 2.4475e-17
C_x_PM_ISO_FENCE0_X4%VSS_c2 VSS x_PM_ISO_FENCE0_X4%VSS_27 2.5538e-17
C_x_PM_ISO_FENCE0_X4%VSS_c3 VSS N_VSS_M5_d 2.29142e-17
C_x_PM_ISO_FENCE0_X4%VSS_c4 VSS VSS 2.80728e-18
C_x_PM_ISO_FENCE0_X4%VSS_c5 VSS x_PM_ISO_FENCE0_X4%VSS_20 2.01009e-17
C_x_PM_ISO_FENCE0_X4%VSS_c6 VSS x_PM_ISO_FENCE0_X4%VSS_19 2.48768e-17
C_x_PM_ISO_FENCE0_X4%VSS_c7 VSS N_VSS_M4_s 2.55502e-17
C_x_PM_ISO_FENCE0_X4%VSS_c8 VSS x_PM_ISO_FENCE0_X4%VSS_12 5.90809e-16
C_x_PM_ISO_FENCE0_X4%VSS_c9 VSS x_PM_ISO_FENCE0_X4%VSS_11 1.92462e-17
C_x_PM_ISO_FENCE0_X4%VSS_c10 VSS x_PM_ISO_FENCE0_X4%VSS_10 2.334e-16
R_x_PM_ISO_FENCE0_X4%VSS_r11 VSS x_PM_ISO_FENCE0_X4%VSS_43 0.457895
R_x_PM_ISO_FENCE0_X4%VSS_r12 x_PM_ISO_FENCE0_X4%VSS_41 VSS 0.424928
R_x_PM_ISO_FENCE0_X4%VSS_r13 N_VSS_M7_d x_PM_ISO_FENCE0_X4%VSS_43 1.12643
R_x_PM_ISO_FENCE0_X4%VSS_r14 x_PM_ISO_FENCE0_X4%VSS_43 x_PM_ISO_FENCE0_X4%VSS_27 0.075426
R_x_PM_ISO_FENCE0_X4%VSS_r15 x_PM_ISO_FENCE0_X4%VSS_28 x_PM_ISO_FENCE0_X4%VSS_27 0.692941
R_x_PM_ISO_FENCE0_X4%VSS_r16 N_VSS_M5_d VSS 0.366429
R_x_PM_ISO_FENCE0_X4%VSS_r17 VSS x_PM_ISO_FENCE0_X4%VSS_28 0.073144
R_x_PM_ISO_FENCE0_X4%VSS_r18 x_PM_ISO_FENCE0_X4%VSS_41 x_PM_ISO_FENCE0_X4%VSS_20 0.075366
R_x_PM_ISO_FENCE0_X4%VSS_r19 VSS x_PM_ISO_FENCE0_X4%VSS_19 0.073144
R_x_PM_ISO_FENCE0_X4%VSS_r20 x_PM_ISO_FENCE0_X4%VSS_20 x_PM_ISO_FENCE0_X4%VSS_19 0.681765
R_x_PM_ISO_FENCE0_X4%VSS_r21 N_VSS_M4_s x_PM_ISO_FENCE0_X4%VSS_41 1.12643
R_x_PM_ISO_FENCE0_X4%VSS_r22 VSS x_PM_ISO_FENCE0_X4%VSS_12 9.15353
R_x_PM_ISO_FENCE0_X4%VSS_r23 VSS x_PM_ISO_FENCE0_X4%VSS_11 0.140282
R_x_PM_ISO_FENCE0_X4%VSS_r24 VSS x_PM_ISO_FENCE0_X4%VSS_10 0.143808
R_x_PM_ISO_FENCE0_X4%VSS_r25 x_PM_ISO_FENCE0_X4%VSS_11 x_PM_ISO_FENCE0_X4%VSS_10 7.68941
C_x_PM_ISO_FENCE0_X4%EN_c0 VSS x_PM_ISO_FENCE0_X4%EN_35 8.00659e-18
C_x_PM_ISO_FENCE0_X4%EN_c1 VSS x_PM_ISO_FENCE0_X4%EN_26 1.36166e-17
C_x_PM_ISO_FENCE0_X4%EN_c2 VSS x_PM_ISO_FENCE0_X4%EN_24 6.49695e-18
C_x_PM_ISO_FENCE0_X4%EN_c3 VSS x_PM_ISO_FENCE0_X4%EN_22 1.91625e-17
C_x_PM_ISO_FENCE0_X4%EN_c4 VSS x_PM_ISO_FENCE0_X4%EN_20 4.69701e-18
C_x_PM_ISO_FENCE0_X4%EN_c5 VSS x_PM_ISO_FENCE0_X4%EN_19 5.69538e-17
C_x_PM_ISO_FENCE0_X4%EN_c6 VSS x_PM_ISO_FENCE0_X4%EN_18 1.23114e-17
C_x_PM_ISO_FENCE0_X4%EN_c7 VSS N_EN_M3_g 5.21955e-17
C_x_PM_ISO_FENCE0_X4%EN_c8 VSS N_EN_M7_g 6.32988e-17
C_x_PM_ISO_FENCE0_X4%EN_c9 VSS N_EN_M0_g 5.83657e-17
C_x_PM_ISO_FENCE0_X4%EN_c10 VSS N_EN_M4_g 5.48242e-17
R_x_PM_ISO_FENCE0_X4%EN_r11 x_PM_ISO_FENCE0_X4%EN_32 EN 0.287087
R_x_PM_ISO_FENCE0_X4%EN_r12 x_PM_ISO_FENCE0_X4%EN_35 x_PM_ISO_FENCE0_X4%EN_28 3.9
R_x_PM_ISO_FENCE0_X4%EN_r13 x_PM_ISO_FENCE0_X4%EN_28 x_PM_ISO_FENCE0_X4%EN_26 25.0012
R_x_PM_ISO_FENCE0_X4%EN_r14 EN x_PM_ISO_FENCE0_X4%EN_26 0.007917
R_x_PM_ISO_FENCE0_X4%EN_r15 x_PM_ISO_FENCE0_X4%EN_39 x_PM_ISO_FENCE0_X4%EN_24 4.7687
R_x_PM_ISO_FENCE0_X4%EN_r16 x_PM_ISO_FENCE0_X4%EN_38 x_PM_ISO_FENCE0_X4%EN_24 4.7687
R_x_PM_ISO_FENCE0_X4%EN_r17 x_PM_ISO_FENCE0_X4%EN_24 x_PM_ISO_FENCE0_X4%EN_22 25.0012
R_x_PM_ISO_FENCE0_X4%EN_r18 x_PM_ISO_FENCE0_X4%EN_22 x_PM_ISO_FENCE0_X4%EN_21 0.95
R_x_PM_ISO_FENCE0_X4%EN_r19 x_PM_ISO_FENCE0_X4%EN_21 x_PM_ISO_FENCE0_X4%EN_19 0.223553
R_x_PM_ISO_FENCE0_X4%EN_r20 x_PM_ISO_FENCE0_X4%EN_20 x_PM_ISO_FENCE0_X4%EN_19 3.01286
R_x_PM_ISO_FENCE0_X4%EN_r21 x_PM_ISO_FENCE0_X4%EN_20 x_PM_ISO_FENCE0_X4%EN_18 0.212317
R_x_PM_ISO_FENCE0_X4%EN_r22 x_PM_ISO_FENCE0_X4%EN_18 x_PM_ISO_FENCE0_X4%EN_32 1.52
R_x_PM_ISO_FENCE0_X4%EN_r23 N_EN_M3_g x_PM_ISO_FENCE0_X4%EN_39 47.19
R_x_PM_ISO_FENCE0_X4%EN_r24 N_EN_M7_g x_PM_ISO_FENCE0_X4%EN_38 64.35
R_x_PM_ISO_FENCE0_X4%EN_r25 x_PM_ISO_FENCE0_X4%EN_35 x_PM_ISO_FENCE0_X4%EN_5 1.95
R_x_PM_ISO_FENCE0_X4%EN_r26 N_EN_M0_g x_PM_ISO_FENCE0_X4%EN_5 61.23
R_x_PM_ISO_FENCE0_X4%EN_r27 x_PM_ISO_FENCE0_X4%EN_35 x_PM_ISO_FENCE0_X4%EN_1 1.95
R_x_PM_ISO_FENCE0_X4%EN_r28 N_EN_M4_g x_PM_ISO_FENCE0_X4%EN_1 50.31
C_x_PM_ISO_FENCE0_X4%Z_c0 VSS N_Z_M6_d 6.58273e-17
C_x_PM_ISO_FENCE0_X4%Z_c1 VSS Z 9.48179e-17
C_x_PM_ISO_FENCE0_X4%Z_c2 VSS x_PM_ISO_FENCE0_X4%Z_4 3.12251e-17
R_x_PM_ISO_FENCE0_X4%Z_r3 N_Z_M6_d x_PM_ISO_FENCE0_X4%Z_14 1.00429
R_x_PM_ISO_FENCE0_X4%Z_r4 N_Z_M1_d Z 1.786
R_x_PM_ISO_FENCE0_X4%Z_r5 x_PM_ISO_FENCE0_X4%Z_14 x_PM_ISO_FENCE0_X4%Z_8 0.095
R_x_PM_ISO_FENCE0_X4%Z_r6 Z x_PM_ISO_FENCE0_X4%Z_8 0.684
R_x_PM_ISO_FENCE0_X4%Z_r7 x_PM_ISO_FENCE0_X4%Z_14 x_PM_ISO_FENCE0_X4%Z_4 0.203571
R_x_PM_ISO_FENCE0_X4%Z_r8 N_Z_M4_d x_PM_ISO_FENCE0_X4%Z_4 0.827857
C_x_PM_ISO_FENCE0_X4%A_c0 VSS A 6.58804e-17
C_x_PM_ISO_FENCE0_X4%A_c1 VSS x_PM_ISO_FENCE0_X4%A_22 8.75624e-18
C_x_PM_ISO_FENCE0_X4%A_c2 VSS x_PM_ISO_FENCE0_X4%A_19 4.24723e-18
C_x_PM_ISO_FENCE0_X4%A_c3 VSS N_A_M2_g 6.14585e-17
C_x_PM_ISO_FENCE0_X4%A_c4 VSS N_A_M6_g 3.57612e-17
C_x_PM_ISO_FENCE0_X4%A_c5 VSS x_PM_ISO_FENCE0_X4%A_9 1.26351e-17
C_x_PM_ISO_FENCE0_X4%A_c6 VSS N_A_M1_g 6.17243e-17
C_x_PM_ISO_FENCE0_X4%A_c7 VSS N_A_M5_g 3.61248e-17
R_x_PM_ISO_FENCE0_X4%A_r8 x_PM_ISO_FENCE0_X4%A_22 x_PM_ISO_FENCE0_X4%A_27 4.94
R_x_PM_ISO_FENCE0_X4%A_r9 x_PM_ISO_FENCE0_X4%A_22 x_PM_ISO_FENCE0_X4%A_20 25.0012
R_x_PM_ISO_FENCE0_X4%A_r10 A x_PM_ISO_FENCE0_X4%A_20 0.117353
R_x_PM_ISO_FENCE0_X4%A_r11 x_PM_ISO_FENCE0_X4%A_27 x_PM_ISO_FENCE0_X4%A_15 1.95
R_x_PM_ISO_FENCE0_X4%A_r12 N_A_M2_g x_PM_ISO_FENCE0_X4%A_15 77.61
R_x_PM_ISO_FENCE0_X4%A_r13 x_PM_ISO_FENCE0_X4%A_27 x_PM_ISO_FENCE0_X4%A_11 1.95
R_x_PM_ISO_FENCE0_X4%A_r14 N_A_M6_g x_PM_ISO_FENCE0_X4%A_11 33.93
R_x_PM_ISO_FENCE0_X4%A_r15 x_PM_ISO_FENCE0_X4%A_19 x_PM_ISO_FENCE0_X4%A_10 0.043368
R_x_PM_ISO_FENCE0_X4%A_r16 x_PM_ISO_FENCE0_X4%A_27 x_PM_ISO_FENCE0_X4%A_9 2.6
R_x_PM_ISO_FENCE0_X4%A_r17 x_PM_ISO_FENCE0_X4%A_10 x_PM_ISO_FENCE0_X4%A_9 14.56
R_x_PM_ISO_FENCE0_X4%A_r18 x_PM_ISO_FENCE0_X4%A_19 x_PM_ISO_FENCE0_X4%A_5 4.56151
R_x_PM_ISO_FENCE0_X4%A_r19 N_A_M1_g x_PM_ISO_FENCE0_X4%A_5 77.61
R_x_PM_ISO_FENCE0_X4%A_r20 x_PM_ISO_FENCE0_X4%A_19 x_PM_ISO_FENCE0_X4%A_1 4.56151
R_x_PM_ISO_FENCE0_X4%A_r21 N_A_M5_g x_PM_ISO_FENCE0_X4%A_1 33.93
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE1N_X1.                                                  *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE1N_X1 VDD VSS EN Z A
*.PININFO VDD:P VSS:G EN:I Z:O A:I
*.EQN Z=!(A * EN)
M_M2 N_Z_M0_d N_EN_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.205000U L=0.050000U
M_M3 N_VDD_M1_d N_A_M1_g N_Z_M0_d VDD PMOS_VTL W=0.205000U L=0.050000U
M_M0 6 N_EN_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_Z_M3_d N_A_M3_g 6 VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_ISO_FENCE1N_X1%VDD_c0 VSS x_PM_ISO_FENCE1N_X1%VDD_24 2.73213e-16
C_x_PM_ISO_FENCE1N_X1%VDD_c1 VSS N_VDD_M1_d 1.15864e-17
C_x_PM_ISO_FENCE1N_X1%VDD_c2 VSS x_PM_ISO_FENCE1N_X1%VDD_19 1.90806e-17
C_x_PM_ISO_FENCE1N_X1%VDD_c3 VSS x_PM_ISO_FENCE1N_X1%VDD_18 2.14262e-17
C_x_PM_ISO_FENCE1N_X1%VDD_c4 VSS N_VDD_M0_s 1.09739e-17
C_x_PM_ISO_FENCE1N_X1%VDD_c5 VSS x_PM_ISO_FENCE1N_X1%VDD_13 1.92462e-17
C_x_PM_ISO_FENCE1N_X1%VDD_c6 VSS x_PM_ISO_FENCE1N_X1%VDD_12 2.334e-16
C_x_PM_ISO_FENCE1N_X1%VDD_c7 VSS x_PM_ISO_FENCE1N_X1%VDD_9 5.65101e-16
R_x_PM_ISO_FENCE1N_X1%VDD_r8 VDD x_PM_ISO_FENCE1N_X1%VDD_34 0.490833
R_x_PM_ISO_FENCE1N_X1%VDD_r9 x_PM_ISO_FENCE1N_X1%VDD_33 VDD 0.392137
R_x_PM_ISO_FENCE1N_X1%VDD_r10 VDD x_PM_ISO_FENCE1N_X1%VDD_24 0.144103
R_x_PM_ISO_FENCE1N_X1%VDD_r11 VDD x_PM_ISO_FENCE1N_X1%VDD_24 3.84471
R_x_PM_ISO_FENCE1N_X1%VDD_r12 N_VDD_M1_d x_PM_ISO_FENCE1N_X1%VDD_34 0.556429
R_x_PM_ISO_FENCE1N_X1%VDD_r13 x_PM_ISO_FENCE1N_X1%VDD_33 x_PM_ISO_FENCE1N_X1%VDD_19 0.0753
R_x_PM_ISO_FENCE1N_X1%VDD_r14 x_PM_ISO_FENCE1N_X1%VDD_34 x_PM_ISO_FENCE1N_X1%VDD_18 0.075492
R_x_PM_ISO_FENCE1N_X1%VDD_r15 x_PM_ISO_FENCE1N_X1%VDD_19 x_PM_ISO_FENCE1N_X1%VDD_18 0.681765
R_x_PM_ISO_FENCE1N_X1%VDD_r16 N_VDD_M0_s x_PM_ISO_FENCE1N_X1%VDD_33 0.556429
R_x_PM_ISO_FENCE1N_X1%VDD_r17 VDD x_PM_ISO_FENCE1N_X1%VDD_13 0.140282
R_x_PM_ISO_FENCE1N_X1%VDD_r18 VDD x_PM_ISO_FENCE1N_X1%VDD_12 0.143516
R_x_PM_ISO_FENCE1N_X1%VDD_r19 x_PM_ISO_FENCE1N_X1%VDD_13 x_PM_ISO_FENCE1N_X1%VDD_12 7.68941
R_x_PM_ISO_FENCE1N_X1%VDD_r20 VDD x_PM_ISO_FENCE1N_X1%VDD_9 8.72882
C_x_PM_ISO_FENCE1N_X1%VSS_c0 VSS VSS 2.61735e-16
C_x_PM_ISO_FENCE1N_X1%VSS_c1 VSS x_PM_ISO_FENCE1N_X1%VSS_18 1.89914e-17
C_x_PM_ISO_FENCE1N_X1%VSS_c2 VSS x_PM_ISO_FENCE1N_X1%VSS_17 4.81634e-17
C_x_PM_ISO_FENCE1N_X1%VSS_c3 VSS N_VSS_M2_s 1.35531e-17
C_x_PM_ISO_FENCE1N_X1%VSS_c4 VSS x_PM_ISO_FENCE1N_X1%VSS_10 5.65101e-16
C_x_PM_ISO_FENCE1N_X1%VSS_c5 VSS x_PM_ISO_FENCE1N_X1%VSS_9 1.92462e-17
C_x_PM_ISO_FENCE1N_X1%VSS_c6 VSS x_PM_ISO_FENCE1N_X1%VSS_8 2.334e-16
R_x_PM_ISO_FENCE1N_X1%VSS_r7 x_PM_ISO_FENCE1N_X1%VSS_29 VSS 0.392137
R_x_PM_ISO_FENCE1N_X1%VSS_r8 x_PM_ISO_FENCE1N_X1%VSS_29 x_PM_ISO_FENCE1N_X1%VSS_18 0.0753
R_x_PM_ISO_FENCE1N_X1%VSS_r9 VSS x_PM_ISO_FENCE1N_X1%VSS_18 0.391176
R_x_PM_ISO_FENCE1N_X1%VSS_r10 x_PM_ISO_FENCE1N_X1%VSS_17 VSS 0.13879
R_x_PM_ISO_FENCE1N_X1%VSS_r11 VSS x_PM_ISO_FENCE1N_X1%VSS_17 0.737647
R_x_PM_ISO_FENCE1N_X1%VSS_r12 N_VSS_M2_s x_PM_ISO_FENCE1N_X1%VSS_29 0.339286
R_x_PM_ISO_FENCE1N_X1%VSS_r13 VSS x_PM_ISO_FENCE1N_X1%VSS_10 8.72882
R_x_PM_ISO_FENCE1N_X1%VSS_r14 VSS x_PM_ISO_FENCE1N_X1%VSS_9 0.140282
R_x_PM_ISO_FENCE1N_X1%VSS_r15 VSS x_PM_ISO_FENCE1N_X1%VSS_8 0.143516
R_x_PM_ISO_FENCE1N_X1%VSS_r16 x_PM_ISO_FENCE1N_X1%VSS_9 x_PM_ISO_FENCE1N_X1%VSS_8 7.68941
C_x_PM_ISO_FENCE1N_X1%EN_c0 VSS x_PM_ISO_FENCE1N_X1%EN_14 7.48455e-18
C_x_PM_ISO_FENCE1N_X1%EN_c1 VSS x_PM_ISO_FENCE1N_X1%EN_12 3.57062e-17
C_x_PM_ISO_FENCE1N_X1%EN_c2 VSS N_EN_M0_g 7.24244e-17
C_x_PM_ISO_FENCE1N_X1%EN_c3 VSS N_EN_M2_g 3.97978e-17
R_x_PM_ISO_FENCE1N_X1%EN_r4 x_PM_ISO_FENCE1N_X1%EN_18 x_PM_ISO_FENCE1N_X1%EN_14 4.74714
R_x_PM_ISO_FENCE1N_X1%EN_r5 x_PM_ISO_FENCE1N_X1%EN_17 x_PM_ISO_FENCE1N_X1%EN_14 4.74714
R_x_PM_ISO_FENCE1N_X1%EN_r6 x_PM_ISO_FENCE1N_X1%EN_14 x_PM_ISO_FENCE1N_X1%EN_12 25.0012
R_x_PM_ISO_FENCE1N_X1%EN_r7 x_PM_ISO_FENCE1N_X1%EN_12 EN 0.156071
R_x_PM_ISO_FENCE1N_X1%EN_r8 N_EN_M0_g x_PM_ISO_FENCE1N_X1%EN_18 97.11
R_x_PM_ISO_FENCE1N_X1%EN_r9 N_EN_M2_g x_PM_ISO_FENCE1N_X1%EN_17 39
C_x_PM_ISO_FENCE1N_X1%Z_c0 VSS N_Z_M3_d 7.72482e-17
C_x_PM_ISO_FENCE1N_X1%Z_c1 VSS x_PM_ISO_FENCE1N_X1%Z_8 1.08516e-17
C_x_PM_ISO_FENCE1N_X1%Z_c2 VSS x_PM_ISO_FENCE1N_X1%Z_7 1.78802e-17
C_x_PM_ISO_FENCE1N_X1%Z_c3 VSS N_Z_M0_d 5.23761e-17
R_x_PM_ISO_FENCE1N_X1%Z_r4 Z N_Z_M3_d 1.59389
R_x_PM_ISO_FENCE1N_X1%Z_r5 Z x_PM_ISO_FENCE1N_X1%Z_9 0.295556
R_x_PM_ISO_FENCE1N_X1%Z_r6 x_PM_ISO_FENCE1N_X1%Z_9 x_PM_ISO_FENCE1N_X1%Z_7 0.21666
R_x_PM_ISO_FENCE1N_X1%Z_r7 x_PM_ISO_FENCE1N_X1%Z_8 x_PM_ISO_FENCE1N_X1%Z_7 0.624286
R_x_PM_ISO_FENCE1N_X1%Z_r8 x_PM_ISO_FENCE1N_X1%Z_8 x_PM_ISO_FENCE1N_X1%Z_3 0.212317
R_x_PM_ISO_FENCE1N_X1%Z_r9 N_Z_M0_d x_PM_ISO_FENCE1N_X1%Z_3 1.69643
C_x_PM_ISO_FENCE1N_X1%A_c0 VSS x_PM_ISO_FENCE1N_X1%A_18 1.26302e-17
C_x_PM_ISO_FENCE1N_X1%A_c1 VSS x_PM_ISO_FENCE1N_X1%A_12 6.03827e-17
C_x_PM_ISO_FENCE1N_X1%A_c2 VSS N_A_M1_g 8.22098e-17
C_x_PM_ISO_FENCE1N_X1%A_c3 VSS N_A_M3_g 4.43257e-17
R_x_PM_ISO_FENCE1N_X1%A_r4 x_PM_ISO_FENCE1N_X1%A_18 x_PM_ISO_FENCE1N_X1%A_14 3.9
R_x_PM_ISO_FENCE1N_X1%A_r5 x_PM_ISO_FENCE1N_X1%A_14 x_PM_ISO_FENCE1N_X1%A_12 25.0012
R_x_PM_ISO_FENCE1N_X1%A_r6 x_PM_ISO_FENCE1N_X1%A_12 A 0.101786
R_x_PM_ISO_FENCE1N_X1%A_r7 x_PM_ISO_FENCE1N_X1%A_18 x_PM_ISO_FENCE1N_X1%A_5 1.95
R_x_PM_ISO_FENCE1N_X1%A_r8 N_A_M1_g x_PM_ISO_FENCE1N_X1%A_5 97.11
R_x_PM_ISO_FENCE1N_X1%A_r9 x_PM_ISO_FENCE1N_X1%A_18 x_PM_ISO_FENCE1N_X1%A_1 1.95
R_x_PM_ISO_FENCE1N_X1%A_r10 N_A_M3_g x_PM_ISO_FENCE1N_X1%A_1 39
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE1N_X2.                                                  *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE1N_X2 VDD VSS EN Z A
*.PININFO VDD:P VSS:G EN:I Z:O A:I
*.EQN Z=!(A * EN)
M_M2 N_Z_M0_d N_EN_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.415000U L=0.050000U
M_M3 N_VDD_M1_d N_A_M1_g N_Z_M0_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M0 6 N_EN_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.360000U L=0.050000U
M_M1 N_Z_M3_d N_A_M3_g 6 VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_ISO_FENCE1N_X2%VDD_c0 VSS x_PM_ISO_FENCE1N_X2%VDD_24 2.72952e-16
C_x_PM_ISO_FENCE1N_X2%VDD_c1 VSS N_VDD_M1_d 2.77202e-17
C_x_PM_ISO_FENCE1N_X2%VDD_c2 VSS x_PM_ISO_FENCE1N_X2%VDD_19 1.91458e-17
C_x_PM_ISO_FENCE1N_X2%VDD_c3 VSS x_PM_ISO_FENCE1N_X2%VDD_18 2.14584e-17
C_x_PM_ISO_FENCE1N_X2%VDD_c4 VSS N_VDD_M0_s 2.5343e-17
C_x_PM_ISO_FENCE1N_X2%VDD_c5 VSS x_PM_ISO_FENCE1N_X2%VDD_13 1.92462e-17
C_x_PM_ISO_FENCE1N_X2%VDD_c6 VSS x_PM_ISO_FENCE1N_X2%VDD_12 2.334e-16
C_x_PM_ISO_FENCE1N_X2%VDD_c7 VSS x_PM_ISO_FENCE1N_X2%VDD_9 5.65101e-16
R_x_PM_ISO_FENCE1N_X2%VDD_r8 VDD x_PM_ISO_FENCE1N_X2%VDD_34 0.479745
R_x_PM_ISO_FENCE1N_X2%VDD_r9 x_PM_ISO_FENCE1N_X2%VDD_33 VDD 0.392137
R_x_PM_ISO_FENCE1N_X2%VDD_r10 VDD x_PM_ISO_FENCE1N_X2%VDD_24 0.144
R_x_PM_ISO_FENCE1N_X2%VDD_r11 VDD x_PM_ISO_FENCE1N_X2%VDD_24 3.84471
R_x_PM_ISO_FENCE1N_X2%VDD_r12 N_VDD_M1_d x_PM_ISO_FENCE1N_X2%VDD_34 0.502143
R_x_PM_ISO_FENCE1N_X2%VDD_r13 x_PM_ISO_FENCE1N_X2%VDD_33 x_PM_ISO_FENCE1N_X2%VDD_19 0.0753
R_x_PM_ISO_FENCE1N_X2%VDD_r14 x_PM_ISO_FENCE1N_X2%VDD_34 x_PM_ISO_FENCE1N_X2%VDD_18 0.075465
R_x_PM_ISO_FENCE1N_X2%VDD_r15 x_PM_ISO_FENCE1N_X2%VDD_19 x_PM_ISO_FENCE1N_X2%VDD_18 0.692941
R_x_PM_ISO_FENCE1N_X2%VDD_r16 N_VDD_M0_s x_PM_ISO_FENCE1N_X2%VDD_33 0.502143
R_x_PM_ISO_FENCE1N_X2%VDD_r17 VDD x_PM_ISO_FENCE1N_X2%VDD_13 0.140282
R_x_PM_ISO_FENCE1N_X2%VDD_r18 VDD x_PM_ISO_FENCE1N_X2%VDD_12 0.143516
R_x_PM_ISO_FENCE1N_X2%VDD_r19 x_PM_ISO_FENCE1N_X2%VDD_13 x_PM_ISO_FENCE1N_X2%VDD_12 7.68941
R_x_PM_ISO_FENCE1N_X2%VDD_r20 VDD x_PM_ISO_FENCE1N_X2%VDD_9 8.72882
C_x_PM_ISO_FENCE1N_X2%VSS_c0 VSS VSS 2.61735e-16
C_x_PM_ISO_FENCE1N_X2%VSS_c1 VSS x_PM_ISO_FENCE1N_X2%VSS_18 1.90479e-17
C_x_PM_ISO_FENCE1N_X2%VSS_c2 VSS x_PM_ISO_FENCE1N_X2%VSS_17 4.38027e-17
C_x_PM_ISO_FENCE1N_X2%VSS_c3 VSS N_VSS_M2_s 2.48218e-17
C_x_PM_ISO_FENCE1N_X2%VSS_c4 VSS x_PM_ISO_FENCE1N_X2%VSS_10 5.65101e-16
C_x_PM_ISO_FENCE1N_X2%VSS_c5 VSS x_PM_ISO_FENCE1N_X2%VSS_9 1.92462e-17
C_x_PM_ISO_FENCE1N_X2%VSS_c6 VSS x_PM_ISO_FENCE1N_X2%VSS_8 2.334e-16
R_x_PM_ISO_FENCE1N_X2%VSS_r7 x_PM_ISO_FENCE1N_X2%VSS_29 VSS 0.392137
R_x_PM_ISO_FENCE1N_X2%VSS_r8 x_PM_ISO_FENCE1N_X2%VSS_29 x_PM_ISO_FENCE1N_X2%VSS_18 0.0753
R_x_PM_ISO_FENCE1N_X2%VSS_r9 VSS x_PM_ISO_FENCE1N_X2%VSS_18 0.391176
R_x_PM_ISO_FENCE1N_X2%VSS_r10 x_PM_ISO_FENCE1N_X2%VSS_17 VSS 0.13879
R_x_PM_ISO_FENCE1N_X2%VSS_r11 VSS x_PM_ISO_FENCE1N_X2%VSS_17 0.737647
R_x_PM_ISO_FENCE1N_X2%VSS_r12 N_VSS_M2_s x_PM_ISO_FENCE1N_X2%VSS_29 1.09929
R_x_PM_ISO_FENCE1N_X2%VSS_r13 VSS x_PM_ISO_FENCE1N_X2%VSS_10 8.72882
R_x_PM_ISO_FENCE1N_X2%VSS_r14 VSS x_PM_ISO_FENCE1N_X2%VSS_9 0.140282
R_x_PM_ISO_FENCE1N_X2%VSS_r15 VSS x_PM_ISO_FENCE1N_X2%VSS_8 0.143516
R_x_PM_ISO_FENCE1N_X2%VSS_r16 x_PM_ISO_FENCE1N_X2%VSS_9 x_PM_ISO_FENCE1N_X2%VSS_8 7.68941
C_x_PM_ISO_FENCE1N_X2%EN_c0 VSS x_PM_ISO_FENCE1N_X2%EN_14 7.42587e-18
C_x_PM_ISO_FENCE1N_X2%EN_c1 VSS x_PM_ISO_FENCE1N_X2%EN_12 3.57337e-17
C_x_PM_ISO_FENCE1N_X2%EN_c2 VSS N_EN_M0_g 6.57871e-17
C_x_PM_ISO_FENCE1N_X2%EN_c3 VSS N_EN_M2_g 5.5709e-17
R_x_PM_ISO_FENCE1N_X2%EN_r4 x_PM_ISO_FENCE1N_X2%EN_18 x_PM_ISO_FENCE1N_X2%EN_14 4.74714
R_x_PM_ISO_FENCE1N_X2%EN_r5 x_PM_ISO_FENCE1N_X2%EN_17 x_PM_ISO_FENCE1N_X2%EN_14 4.74714
R_x_PM_ISO_FENCE1N_X2%EN_r6 x_PM_ISO_FENCE1N_X2%EN_14 x_PM_ISO_FENCE1N_X2%EN_12 25.0012
R_x_PM_ISO_FENCE1N_X2%EN_r7 x_PM_ISO_FENCE1N_X2%EN_12 EN 0.156071
R_x_PM_ISO_FENCE1N_X2%EN_r8 N_EN_M0_g x_PM_ISO_FENCE1N_X2%EN_18 60.45
R_x_PM_ISO_FENCE1N_X2%EN_r9 N_EN_M2_g x_PM_ISO_FENCE1N_X2%EN_17 46.8
C_x_PM_ISO_FENCE1N_X2%Z_c0 VSS Z 8.40565e-18
C_x_PM_ISO_FENCE1N_X2%Z_c1 VSS N_Z_M3_d 7.40805e-17
C_x_PM_ISO_FENCE1N_X2%Z_c2 VSS x_PM_ISO_FENCE1N_X2%Z_8 1.65869e-17
C_x_PM_ISO_FENCE1N_X2%Z_c3 VSS x_PM_ISO_FENCE1N_X2%Z_7 1.74222e-17
C_x_PM_ISO_FENCE1N_X2%Z_c4 VSS N_Z_M0_d 4.56903e-17
R_x_PM_ISO_FENCE1N_X2%Z_r5 Z N_Z_M3_d 1.42458
R_x_PM_ISO_FENCE1N_X2%Z_r6 Z x_PM_ISO_FENCE1N_X2%Z_7 0.194994
R_x_PM_ISO_FENCE1N_X2%Z_r7 x_PM_ISO_FENCE1N_X2%Z_8 x_PM_ISO_FENCE1N_X2%Z_7 0.651429
R_x_PM_ISO_FENCE1N_X2%Z_r8 x_PM_ISO_FENCE1N_X2%Z_8 x_PM_ISO_FENCE1N_X2%Z_3 0.212317
R_x_PM_ISO_FENCE1N_X2%Z_r9 N_Z_M0_d x_PM_ISO_FENCE1N_X2%Z_3 1.20786
C_x_PM_ISO_FENCE1N_X2%A_c0 VSS x_PM_ISO_FENCE1N_X2%A_18 1.2727e-17
C_x_PM_ISO_FENCE1N_X2%A_c1 VSS x_PM_ISO_FENCE1N_X2%A_12 7.06323e-17
C_x_PM_ISO_FENCE1N_X2%A_c2 VSS N_A_M1_g 7.3577e-17
C_x_PM_ISO_FENCE1N_X2%A_c3 VSS N_A_M3_g 5.90648e-17
R_x_PM_ISO_FENCE1N_X2%A_r4 x_PM_ISO_FENCE1N_X2%A_18 x_PM_ISO_FENCE1N_X2%A_14 3.9
R_x_PM_ISO_FENCE1N_X2%A_r5 x_PM_ISO_FENCE1N_X2%A_14 x_PM_ISO_FENCE1N_X2%A_12 25.0012
R_x_PM_ISO_FENCE1N_X2%A_r6 x_PM_ISO_FENCE1N_X2%A_12 A 0.101786
R_x_PM_ISO_FENCE1N_X2%A_r7 x_PM_ISO_FENCE1N_X2%A_18 x_PM_ISO_FENCE1N_X2%A_5 1.95
R_x_PM_ISO_FENCE1N_X2%A_r8 N_A_M1_g x_PM_ISO_FENCE1N_X2%A_5 60.45
R_x_PM_ISO_FENCE1N_X2%A_r9 x_PM_ISO_FENCE1N_X2%A_18 x_PM_ISO_FENCE1N_X2%A_1 1.95
R_x_PM_ISO_FENCE1N_X2%A_r10 N_A_M3_g x_PM_ISO_FENCE1N_X2%A_1 46.8
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE1N_X4.                                                  *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE1N_X4 VDD VSS EN Z A
*.PININFO VDD:P VSS:G EN:I Z:O A:I
*.EQN Z=!(A * EN)
M_M4 N_Z_M0_d N_EN_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.415000U L=0.050000U
M_M5 N_VDD_M1_d N_A_M1_g N_Z_M0_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M6 N_Z_M2_d N_A_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M7 N_VDD_M3_d N_EN_M3_g N_Z_M2_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M0 6 N_EN_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.360000U L=0.050000U
M_M1 N_Z_M5_d N_A_M5_g 6 VSS NMOS_VTL W=0.360000U L=0.050000U
M_M2 7 N_A_M6_g N_Z_M5_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M3 N_VSS_M7_d N_EN_M7_g 7 VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_ISO_FENCE1N_X4%VDD_c0 VSS x_PM_ISO_FENCE1N_X4%VDD_41 2.83664e-18
C_x_PM_ISO_FENCE1N_X4%VDD_c1 VSS x_PM_ISO_FENCE1N_X4%VDD_31 2.72843e-16
C_x_PM_ISO_FENCE1N_X4%VDD_c2 VSS N_VDD_M3_d 2.31843e-17
C_x_PM_ISO_FENCE1N_X4%VDD_c3 VSS x_PM_ISO_FENCE1N_X4%VDD_25 2.54131e-17
C_x_PM_ISO_FENCE1N_X4%VDD_c4 VSS N_VDD_M1_d 2.31796e-17
C_x_PM_ISO_FENCE1N_X4%VDD_c5 VSS x_PM_ISO_FENCE1N_X4%VDD_20 2.01219e-17
C_x_PM_ISO_FENCE1N_X4%VDD_c6 VSS x_PM_ISO_FENCE1N_X4%VDD_19 2.45605e-17
C_x_PM_ISO_FENCE1N_X4%VDD_c7 VSS N_VDD_M0_s 2.52216e-17
C_x_PM_ISO_FENCE1N_X4%VDD_c8 VSS x_PM_ISO_FENCE1N_X4%VDD_14 1.92462e-17
C_x_PM_ISO_FENCE1N_X4%VDD_c9 VSS x_PM_ISO_FENCE1N_X4%VDD_13 2.334e-16
C_x_PM_ISO_FENCE1N_X4%VDD_c10 VSS x_PM_ISO_FENCE1N_X4%VDD_10 5.90809e-16
R_x_PM_ISO_FENCE1N_X4%VDD_r11 VDD x_PM_ISO_FENCE1N_X4%VDD_42 0.457895
R_x_PM_ISO_FENCE1N_X4%VDD_r12 x_PM_ISO_FENCE1N_X4%VDD_40 VDD 0.424928
R_x_PM_ISO_FENCE1N_X4%VDD_r13 VDD x_PM_ISO_FENCE1N_X4%VDD_31 0.143847
R_x_PM_ISO_FENCE1N_X4%VDD_r14 VDD x_PM_ISO_FENCE1N_X4%VDD_31 3.84471
R_x_PM_ISO_FENCE1N_X4%VDD_r15 N_VDD_M3_d x_PM_ISO_FENCE1N_X4%VDD_42 0.393571
R_x_PM_ISO_FENCE1N_X4%VDD_r16 x_PM_ISO_FENCE1N_X4%VDD_41 x_PM_ISO_FENCE1N_X4%VDD_26 0.073144
R_x_PM_ISO_FENCE1N_X4%VDD_r17 x_PM_ISO_FENCE1N_X4%VDD_42 x_PM_ISO_FENCE1N_X4%VDD_25 0.075426
R_x_PM_ISO_FENCE1N_X4%VDD_r18 x_PM_ISO_FENCE1N_X4%VDD_26 x_PM_ISO_FENCE1N_X4%VDD_25 0.692941
R_x_PM_ISO_FENCE1N_X4%VDD_r19 x_PM_ISO_FENCE1N_X4%VDD_41 x_PM_ISO_FENCE1N_X4%VDD_21 0.145286
R_x_PM_ISO_FENCE1N_X4%VDD_r20 N_VDD_M1_d x_PM_ISO_FENCE1N_X4%VDD_21 0.393571
R_x_PM_ISO_FENCE1N_X4%VDD_r21 x_PM_ISO_FENCE1N_X4%VDD_40 x_PM_ISO_FENCE1N_X4%VDD_20 0.075366
R_x_PM_ISO_FENCE1N_X4%VDD_r22 x_PM_ISO_FENCE1N_X4%VDD_41 x_PM_ISO_FENCE1N_X4%VDD_19 0.073144
R_x_PM_ISO_FENCE1N_X4%VDD_r23 x_PM_ISO_FENCE1N_X4%VDD_20 x_PM_ISO_FENCE1N_X4%VDD_19 0.681765
R_x_PM_ISO_FENCE1N_X4%VDD_r24 N_VDD_M0_s x_PM_ISO_FENCE1N_X4%VDD_40 0.393571
R_x_PM_ISO_FENCE1N_X4%VDD_r25 VDD x_PM_ISO_FENCE1N_X4%VDD_14 0.140282
R_x_PM_ISO_FENCE1N_X4%VDD_r26 VDD x_PM_ISO_FENCE1N_X4%VDD_13 0.143808
R_x_PM_ISO_FENCE1N_X4%VDD_r27 x_PM_ISO_FENCE1N_X4%VDD_14 x_PM_ISO_FENCE1N_X4%VDD_13 7.68941
R_x_PM_ISO_FENCE1N_X4%VDD_r28 VDD x_PM_ISO_FENCE1N_X4%VDD_10 9.15353
C_x_PM_ISO_FENCE1N_X4%VSS_c0 VSS VSS 2.72286e-16
C_x_PM_ISO_FENCE1N_X4%VSS_c1 VSS N_VSS_M7_d 2.92902e-17
C_x_PM_ISO_FENCE1N_X4%VSS_c2 VSS x_PM_ISO_FENCE1N_X4%VSS_19 2.01478e-17
C_x_PM_ISO_FENCE1N_X4%VSS_c3 VSS x_PM_ISO_FENCE1N_X4%VSS_18 4.96879e-17
C_x_PM_ISO_FENCE1N_X4%VSS_c4 VSS N_VSS_M4_s 2.40586e-17
C_x_PM_ISO_FENCE1N_X4%VSS_c5 VSS x_PM_ISO_FENCE1N_X4%VSS_11 5.90809e-16
C_x_PM_ISO_FENCE1N_X4%VSS_c6 VSS x_PM_ISO_FENCE1N_X4%VSS_10 1.92462e-17
C_x_PM_ISO_FENCE1N_X4%VSS_c7 VSS x_PM_ISO_FENCE1N_X4%VSS_9 2.334e-16
R_x_PM_ISO_FENCE1N_X4%VSS_r8 VSS x_PM_ISO_FENCE1N_X4%VSS_35 0.457895
R_x_PM_ISO_FENCE1N_X4%VSS_r9 x_PM_ISO_FENCE1N_X4%VSS_34 VSS 0.424928
R_x_PM_ISO_FENCE1N_X4%VSS_r10 N_VSS_M7_d x_PM_ISO_FENCE1N_X4%VSS_35 1.39786
R_x_PM_ISO_FENCE1N_X4%VSS_r11 x_PM_ISO_FENCE1N_X4%VSS_34 x_PM_ISO_FENCE1N_X4%VSS_19 0.075366
R_x_PM_ISO_FENCE1N_X4%VSS_r12 VSS x_PM_ISO_FENCE1N_X4%VSS_19 0.782353
R_x_PM_ISO_FENCE1N_X4%VSS_r13 x_PM_ISO_FENCE1N_X4%VSS_35 x_PM_ISO_FENCE1N_X4%VSS_18 0.075426
R_x_PM_ISO_FENCE1N_X4%VSS_r14 VSS x_PM_ISO_FENCE1N_X4%VSS_18 0.748824
R_x_PM_ISO_FENCE1N_X4%VSS_r15 N_VSS_M4_s x_PM_ISO_FENCE1N_X4%VSS_34 1.39786
R_x_PM_ISO_FENCE1N_X4%VSS_r16 VSS x_PM_ISO_FENCE1N_X4%VSS_11 9.15353
R_x_PM_ISO_FENCE1N_X4%VSS_r17 VSS x_PM_ISO_FENCE1N_X4%VSS_10 0.140282
R_x_PM_ISO_FENCE1N_X4%VSS_r18 VSS x_PM_ISO_FENCE1N_X4%VSS_9 0.143808
R_x_PM_ISO_FENCE1N_X4%VSS_r19 x_PM_ISO_FENCE1N_X4%VSS_10 x_PM_ISO_FENCE1N_X4%VSS_9 7.68941
C_x_PM_ISO_FENCE1N_X4%EN_c0 VSS x_PM_ISO_FENCE1N_X4%EN_29 1.01357e-17
C_x_PM_ISO_FENCE1N_X4%EN_c1 VSS x_PM_ISO_FENCE1N_X4%EN_27 5.59874e-17
C_x_PM_ISO_FENCE1N_X4%EN_c2 VSS x_PM_ISO_FENCE1N_X4%EN_25 2.60601e-17
C_x_PM_ISO_FENCE1N_X4%EN_c3 VSS x_PM_ISO_FENCE1N_X4%EN_24 1.56317e-16
C_x_PM_ISO_FENCE1N_X4%EN_c4 VSS x_PM_ISO_FENCE1N_X4%EN_20 6.37169e-18
C_x_PM_ISO_FENCE1N_X4%EN_c5 VSS x_PM_ISO_FENCE1N_X4%EN_18 3.0969e-17
C_x_PM_ISO_FENCE1N_X4%EN_c6 VSS N_EN_M3_g 5.93948e-17
C_x_PM_ISO_FENCE1N_X4%EN_c7 VSS N_EN_M7_g 6.63651e-17
C_x_PM_ISO_FENCE1N_X4%EN_c8 VSS N_EN_M0_g 5.08393e-17
C_x_PM_ISO_FENCE1N_X4%EN_c9 VSS N_EN_M4_g 6.1643e-17
R_x_PM_ISO_FENCE1N_X4%EN_r10 x_PM_ISO_FENCE1N_X4%EN_36 x_PM_ISO_FENCE1N_X4%EN_29 4.7687
R_x_PM_ISO_FENCE1N_X4%EN_r11 x_PM_ISO_FENCE1N_X4%EN_35 x_PM_ISO_FENCE1N_X4%EN_29 4.7687
R_x_PM_ISO_FENCE1N_X4%EN_r12 x_PM_ISO_FENCE1N_X4%EN_29 x_PM_ISO_FENCE1N_X4%EN_27 25.0012
R_x_PM_ISO_FENCE1N_X4%EN_r13 x_PM_ISO_FENCE1N_X4%EN_27 x_PM_ISO_FENCE1N_X4%EN_26 0.827857
R_x_PM_ISO_FENCE1N_X4%EN_r14 x_PM_ISO_FENCE1N_X4%EN_26 x_PM_ISO_FENCE1N_X4%EN_24 0.212317
R_x_PM_ISO_FENCE1N_X4%EN_r15 x_PM_ISO_FENCE1N_X4%EN_25 x_PM_ISO_FENCE1N_X4%EN_24 2.09
R_x_PM_ISO_FENCE1N_X4%EN_r16 x_PM_ISO_FENCE1N_X4%EN_33 x_PM_ISO_FENCE1N_X4%EN_20 4.7687
R_x_PM_ISO_FENCE1N_X4%EN_r17 x_PM_ISO_FENCE1N_X4%EN_32 x_PM_ISO_FENCE1N_X4%EN_20 4.7687
R_x_PM_ISO_FENCE1N_X4%EN_r18 x_PM_ISO_FENCE1N_X4%EN_20 x_PM_ISO_FENCE1N_X4%EN_18 25.0012
R_x_PM_ISO_FENCE1N_X4%EN_r19 EN x_PM_ISO_FENCE1N_X4%EN_18 0.005938
R_x_PM_ISO_FENCE1N_X4%EN_r20 x_PM_ISO_FENCE1N_X4%EN_25 x_PM_ISO_FENCE1N_X4%EN_17 0.257632
R_x_PM_ISO_FENCE1N_X4%EN_r21 EN x_PM_ISO_FENCE1N_X4%EN_17 0.320625
R_x_PM_ISO_FENCE1N_X4%EN_r22 N_EN_M3_g x_PM_ISO_FENCE1N_X4%EN_36 44.07
R_x_PM_ISO_FENCE1N_X4%EN_r23 N_EN_M7_g x_PM_ISO_FENCE1N_X4%EN_35 57.72
R_x_PM_ISO_FENCE1N_X4%EN_r24 N_EN_M0_g x_PM_ISO_FENCE1N_X4%EN_33 41.73
R_x_PM_ISO_FENCE1N_X4%EN_r25 N_EN_M4_g x_PM_ISO_FENCE1N_X4%EN_32 60.06
C_x_PM_ISO_FENCE1N_X4%Z_c0 VSS x_PM_ISO_FENCE1N_X4%Z_19 6.20739e-17
C_x_PM_ISO_FENCE1N_X4%Z_c1 VSS x_PM_ISO_FENCE1N_X4%Z_17 1.64719e-17
C_x_PM_ISO_FENCE1N_X4%Z_c2 VSS x_PM_ISO_FENCE1N_X4%Z_16 4.42546e-17
C_x_PM_ISO_FENCE1N_X4%Z_c3 VSS N_Z_M5_d 3.23035e-17
C_x_PM_ISO_FENCE1N_X4%Z_c4 VSS x_PM_ISO_FENCE1N_X4%Z_4 1.707e-16
R_x_PM_ISO_FENCE1N_X4%Z_r5 x_PM_ISO_FENCE1N_X4%Z_19 x_PM_ISO_FENCE1N_X4%Z_18 2.33429
R_x_PM_ISO_FENCE1N_X4%Z_r6 x_PM_ISO_FENCE1N_X4%Z_18 x_PM_ISO_FENCE1N_X4%Z_16 0.212317
R_x_PM_ISO_FENCE1N_X4%Z_r7 x_PM_ISO_FENCE1N_X4%Z_17 x_PM_ISO_FENCE1N_X4%Z_16 1.79143
R_x_PM_ISO_FENCE1N_X4%Z_r8 Z N_Z_M5_d 0.013571
R_x_PM_ISO_FENCE1N_X4%Z_r9 x_PM_ISO_FENCE1N_X4%Z_17 x_PM_ISO_FENCE1N_X4%Z_10 0.212317
R_x_PM_ISO_FENCE1N_X4%Z_r10 Z x_PM_ISO_FENCE1N_X4%Z_10 0.271429
R_x_PM_ISO_FENCE1N_X4%Z_r11 N_Z_M2_d N_Z_M0_d 2.03571
R_x_PM_ISO_FENCE1N_X4%Z_r12 x_PM_ISO_FENCE1N_X4%Z_19 x_PM_ISO_FENCE1N_X4%Z_4 0.212317
R_x_PM_ISO_FENCE1N_X4%Z_r13 N_Z_M2_d x_PM_ISO_FENCE1N_X4%Z_4 0.990714
C_x_PM_ISO_FENCE1N_X4%A_c0 VSS x_PM_ISO_FENCE1N_X4%A_21 6.15181e-17
C_x_PM_ISO_FENCE1N_X4%A_c1 VSS x_PM_ISO_FENCE1N_X4%A_20 4.24954e-18
C_x_PM_ISO_FENCE1N_X4%A_c2 VSS x_PM_ISO_FENCE1N_X4%A_19 6.90872e-18
C_x_PM_ISO_FENCE1N_X4%A_c3 VSS x_PM_ISO_FENCE1N_X4%A_18 4.82125e-18
C_x_PM_ISO_FENCE1N_X4%A_c4 VSS N_A_M2_g 4.80591e-17
C_x_PM_ISO_FENCE1N_X4%A_c5 VSS N_A_M6_g 4.64729e-17
C_x_PM_ISO_FENCE1N_X4%A_c6 VSS N_A_M1_g 4.80874e-17
C_x_PM_ISO_FENCE1N_X4%A_c7 VSS N_A_M5_g 4.21341e-17
R_x_PM_ISO_FENCE1N_X4%A_r8 x_PM_ISO_FENCE1N_X4%A_23 x_PM_ISO_FENCE1N_X4%A_21 25.0012
R_x_PM_ISO_FENCE1N_X4%A_r9 A x_PM_ISO_FENCE1N_X4%A_21 0.105556
R_x_PM_ISO_FENCE1N_X4%A_r10 x_PM_ISO_FENCE1N_X4%A_23 x_PM_ISO_FENCE1N_X4%A_19 7.02
R_x_PM_ISO_FENCE1N_X4%A_r11 x_PM_ISO_FENCE1N_X4%A_20 x_PM_ISO_FENCE1N_X4%A_19 0.043368
R_x_PM_ISO_FENCE1N_X4%A_r12 x_PM_ISO_FENCE1N_X4%A_23 x_PM_ISO_FENCE1N_X4%A_17 7.54
R_x_PM_ISO_FENCE1N_X4%A_r13 x_PM_ISO_FENCE1N_X4%A_18 x_PM_ISO_FENCE1N_X4%A_17 0.043368
R_x_PM_ISO_FENCE1N_X4%A_r14 x_PM_ISO_FENCE1N_X4%A_20 x_PM_ISO_FENCE1N_X4%A_13 4.56151
R_x_PM_ISO_FENCE1N_X4%A_r15 N_A_M2_g x_PM_ISO_FENCE1N_X4%A_13 47.19
R_x_PM_ISO_FENCE1N_X4%A_r16 x_PM_ISO_FENCE1N_X4%A_20 x_PM_ISO_FENCE1N_X4%A_9 4.56151
R_x_PM_ISO_FENCE1N_X4%A_r17 N_A_M6_g x_PM_ISO_FENCE1N_X4%A_9 54.6
R_x_PM_ISO_FENCE1N_X4%A_r18 x_PM_ISO_FENCE1N_X4%A_18 x_PM_ISO_FENCE1N_X4%A_5 4.56151
R_x_PM_ISO_FENCE1N_X4%A_r19 N_A_M1_g x_PM_ISO_FENCE1N_X4%A_5 47.19
R_x_PM_ISO_FENCE1N_X4%A_r20 x_PM_ISO_FENCE1N_X4%A_18 x_PM_ISO_FENCE1N_X4%A_1 4.56151
R_x_PM_ISO_FENCE1N_X4%A_r21 N_A_M5_g x_PM_ISO_FENCE1N_X4%A_1 54.6
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE1_X1.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE1_X1 VDD VSS A EN Z
*.PININFO VDD:P VSS:G A:I EN:I Z:O
*.EQN Z=(A + EN)
M_M3 7 N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.250000U L=0.050000U
M_M4 N_VDD_M1_d N_EN_M1_g 7 VDD PMOS_VTL W=0.250000U L=0.050000U
M_M5 N_Z_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.205000U L=0.050000U
M_M0 N_3_M3_d N_A_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.155000U L=0.050000U
M_M1 N_VSS_M4_d N_EN_M4_g N_3_M3_d VSS NMOS_VTL W=0.155000U L=0.050000U
M_M2 N_Z_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.155000U L=0.050000U
C_x_PM_ISO_FENCE1_X1%VDD_c0 VSS x_PM_ISO_FENCE1_X1%VDD_35 2.38573e-17
C_x_PM_ISO_FENCE1_X1%VDD_c1 VSS x_PM_ISO_FENCE1_X1%VDD_32 2.98261e-18
C_x_PM_ISO_FENCE1_X1%VDD_c2 VSS x_PM_ISO_FENCE1_X1%VDD_31 1.056e-17
C_x_PM_ISO_FENCE1_X1%VDD_c3 VSS x_PM_ISO_FENCE1_X1%VDD_30 2.334e-16
C_x_PM_ISO_FENCE1_X1%VDD_c4 VSS x_PM_ISO_FENCE1_X1%VDD_21 2.61481e-16
C_x_PM_ISO_FENCE1_X1%VDD_c5 VSS N_VDD_M1_d 3.50746e-17
C_x_PM_ISO_FENCE1_X1%VDD_c6 VSS x_PM_ISO_FENCE1_X1%VDD_13 3.65455e-17
C_x_PM_ISO_FENCE1_X1%VDD_c7 VSS x_PM_ISO_FENCE1_X1%VDD_12 1.92462e-17
C_x_PM_ISO_FENCE1_X1%VDD_c8 VSS x_PM_ISO_FENCE1_X1%VDD_8 5.77955e-16
R_x_PM_ISO_FENCE1_X1%VDD_r9 x_PM_ISO_FENCE1_X1%VDD_35 VDD 0.13879
R_x_PM_ISO_FENCE1_X1%VDD_r10 x_PM_ISO_FENCE1_X1%VDD_31 VDD 0.138595
R_x_PM_ISO_FENCE1_X1%VDD_r11 x_PM_ISO_FENCE1_X1%VDD_30 VDD 0.138985
R_x_PM_ISO_FENCE1_X1%VDD_r12 x_PM_ISO_FENCE1_X1%VDD_21 VDD 0.13879
R_x_PM_ISO_FENCE1_X1%VDD_r13 VDD x_PM_ISO_FENCE1_X1%VDD_21 3.84471
R_x_PM_ISO_FENCE1_X1%VDD_r14 x_PM_ISO_FENCE1_X1%VDD_32 x_PM_ISO_FENCE1_X1%VDD_20 0.073144
R_x_PM_ISO_FENCE1_X1%VDD_r15 x_PM_ISO_FENCE1_X1%VDD_20 x_PM_ISO_FENCE1_X1%VDD_35 0.715294
R_x_PM_ISO_FENCE1_X1%VDD_r16 x_PM_ISO_FENCE1_X1%VDD_32 x_PM_ISO_FENCE1_X1%VDD_15 0.145286
R_x_PM_ISO_FENCE1_X1%VDD_r17 N_VDD_M1_d x_PM_ISO_FENCE1_X1%VDD_15 1.31643
R_x_PM_ISO_FENCE1_X1%VDD_r18 x_PM_ISO_FENCE1_X1%VDD_32 x_PM_ISO_FENCE1_X1%VDD_13 0.073144
R_x_PM_ISO_FENCE1_X1%VDD_r19 x_PM_ISO_FENCE1_X1%VDD_31 x_PM_ISO_FENCE1_X1%VDD_13 1.02824
R_x_PM_ISO_FENCE1_X1%VDD_r20 VDD x_PM_ISO_FENCE1_X1%VDD_12 0.140282
R_x_PM_ISO_FENCE1_X1%VDD_r21 x_PM_ISO_FENCE1_X1%VDD_12 x_PM_ISO_FENCE1_X1%VDD_30 7.68941
R_x_PM_ISO_FENCE1_X1%VDD_r22 VDD x_PM_ISO_FENCE1_X1%VDD_8 8.94118
C_x_PM_ISO_FENCE1_X1%VSS_c0 VSS x_PM_ISO_FENCE1_X1%VSS_40 3.13435e-17
C_x_PM_ISO_FENCE1_X1%VSS_c1 VSS x_PM_ISO_FENCE1_X1%VSS_37 2.92673e-18
C_x_PM_ISO_FENCE1_X1%VSS_c2 VSS VSS 2.61578e-16
C_x_PM_ISO_FENCE1_X1%VSS_c3 VSS N_VSS_M4_d 2.77952e-17
C_x_PM_ISO_FENCE1_X1%VSS_c4 VSS x_PM_ISO_FENCE1_X1%VSS_19 1.90932e-17
C_x_PM_ISO_FENCE1_X1%VSS_c5 VSS x_PM_ISO_FENCE1_X1%VSS_18 2.72326e-17
C_x_PM_ISO_FENCE1_X1%VSS_c6 VSS N_VSS_M3_s 1.64275e-17
C_x_PM_ISO_FENCE1_X1%VSS_c7 VSS x_PM_ISO_FENCE1_X1%VSS_11 5.77955e-16
C_x_PM_ISO_FENCE1_X1%VSS_c8 VSS x_PM_ISO_FENCE1_X1%VSS_10 1.92462e-17
C_x_PM_ISO_FENCE1_X1%VSS_c9 VSS x_PM_ISO_FENCE1_X1%VSS_9 2.334e-16
R_x_PM_ISO_FENCE1_X1%VSS_r10 x_PM_ISO_FENCE1_X1%VSS_40 VSS 0.13879
R_x_PM_ISO_FENCE1_X1%VSS_r11 x_PM_ISO_FENCE1_X1%VSS_36 VSS 0.392137
R_x_PM_ISO_FENCE1_X1%VSS_r12 x_PM_ISO_FENCE1_X1%VSS_37 x_PM_ISO_FENCE1_X1%VSS_27 0.073144
R_x_PM_ISO_FENCE1_X1%VSS_r13 x_PM_ISO_FENCE1_X1%VSS_27 x_PM_ISO_FENCE1_X1%VSS_40 0.715294
R_x_PM_ISO_FENCE1_X1%VSS_r14 x_PM_ISO_FENCE1_X1%VSS_37 x_PM_ISO_FENCE1_X1%VSS_22 0.145286
R_x_PM_ISO_FENCE1_X1%VSS_r15 N_VSS_M4_d x_PM_ISO_FENCE1_X1%VSS_22 0.502143
R_x_PM_ISO_FENCE1_X1%VSS_r16 x_PM_ISO_FENCE1_X1%VSS_36 x_PM_ISO_FENCE1_X1%VSS_19 0.0753
R_x_PM_ISO_FENCE1_X1%VSS_r17 VSS x_PM_ISO_FENCE1_X1%VSS_19 0.603529
R_x_PM_ISO_FENCE1_X1%VSS_r18 x_PM_ISO_FENCE1_X1%VSS_37 x_PM_ISO_FENCE1_X1%VSS_18 0.073144
R_x_PM_ISO_FENCE1_X1%VSS_r19 VSS x_PM_ISO_FENCE1_X1%VSS_18 0.078235
R_x_PM_ISO_FENCE1_X1%VSS_r20 N_VSS_M3_s x_PM_ISO_FENCE1_X1%VSS_36 0.502143
R_x_PM_ISO_FENCE1_X1%VSS_r21 VSS x_PM_ISO_FENCE1_X1%VSS_11 8.94118
R_x_PM_ISO_FENCE1_X1%VSS_r22 VSS x_PM_ISO_FENCE1_X1%VSS_10 0.140282
R_x_PM_ISO_FENCE1_X1%VSS_r23 VSS x_PM_ISO_FENCE1_X1%VSS_9 0.143516
R_x_PM_ISO_FENCE1_X1%VSS_r24 x_PM_ISO_FENCE1_X1%VSS_10 x_PM_ISO_FENCE1_X1%VSS_9 7.68941
C_x_PM_ISO_FENCE1_X1%3_c0 VSS x_PM_ISO_FENCE1_X1%3_30 1.26649e-17
C_x_PM_ISO_FENCE1_X1%3_c1 VSS x_PM_ISO_FENCE1_X1%3_26 9.75917e-17
C_x_PM_ISO_FENCE1_X1%3_c2 VSS x_PM_ISO_FENCE1_X1%3_22 1.00755e-17
C_x_PM_ISO_FENCE1_X1%3_c3 VSS x_PM_ISO_FENCE1_X1%3_21 3.68974e-17
C_x_PM_ISO_FENCE1_X1%3_c4 VSS N_3_M3_d 3.51089e-17
C_x_PM_ISO_FENCE1_X1%3_c5 VSS x_PM_ISO_FENCE1_X1%3_16 5.30423e-18
C_x_PM_ISO_FENCE1_X1%3_c6 VSS x_PM_ISO_FENCE1_X1%3_15 5.63922e-17
C_x_PM_ISO_FENCE1_X1%3_c7 VSS N_3_M0_s 2.44207e-17
C_x_PM_ISO_FENCE1_X1%3_c8 VSS N_3_M2_g 5.25251e-17
C_x_PM_ISO_FENCE1_X1%3_c9 VSS N_3_M5_g 5.58646e-17
R_x_PM_ISO_FENCE1_X1%3_r10 x_PM_ISO_FENCE1_X1%3_30 x_PM_ISO_FENCE1_X1%3_28 4.42
R_x_PM_ISO_FENCE1_X1%3_r11 x_PM_ISO_FENCE1_X1%3_28 x_PM_ISO_FENCE1_X1%3_26 25.0012
R_x_PM_ISO_FENCE1_X1%3_r12 x_PM_ISO_FENCE1_X1%3_26 x_PM_ISO_FENCE1_X1%3_24 1.045
R_x_PM_ISO_FENCE1_X1%3_r13 x_PM_ISO_FENCE1_X1%3_26 x_PM_ISO_FENCE1_X1%3_23 1.12643
R_x_PM_ISO_FENCE1_X1%3_r14 x_PM_ISO_FENCE1_X1%3_23 x_PM_ISO_FENCE1_X1%3_21 0.212317
R_x_PM_ISO_FENCE1_X1%3_r15 x_PM_ISO_FENCE1_X1%3_22 x_PM_ISO_FENCE1_X1%3_21 0.895714
R_x_PM_ISO_FENCE1_X1%3_r16 x_PM_ISO_FENCE1_X1%3_22 x_PM_ISO_FENCE1_X1%3_17 0.212317
R_x_PM_ISO_FENCE1_X1%3_r17 N_3_M3_d x_PM_ISO_FENCE1_X1%3_17 0.610714
R_x_PM_ISO_FENCE1_X1%3_r18 x_PM_ISO_FENCE1_X1%3_24 x_PM_ISO_FENCE1_X1%3_15 0.212317
R_x_PM_ISO_FENCE1_X1%3_r19 x_PM_ISO_FENCE1_X1%3_16 x_PM_ISO_FENCE1_X1%3_15 1.92714
R_x_PM_ISO_FENCE1_X1%3_r20 x_PM_ISO_FENCE1_X1%3_16 x_PM_ISO_FENCE1_X1%3_11 0.212317
R_x_PM_ISO_FENCE1_X1%3_r21 N_3_M0_s x_PM_ISO_FENCE1_X1%3_11 1.045
R_x_PM_ISO_FENCE1_X1%3_r22 x_PM_ISO_FENCE1_X1%3_30 x_PM_ISO_FENCE1_X1%3_5 1.95
R_x_PM_ISO_FENCE1_X1%3_r23 N_3_M2_g x_PM_ISO_FENCE1_X1%3_5 53.43
R_x_PM_ISO_FENCE1_X1%3_r24 x_PM_ISO_FENCE1_X1%3_30 x_PM_ISO_FENCE1_X1%3_1 1.95
R_x_PM_ISO_FENCE1_X1%3_r25 N_3_M5_g x_PM_ISO_FENCE1_X1%3_1 58.11
C_x_PM_ISO_FENCE1_X1%A_c0 VSS x_PM_ISO_FENCE1_X1%A_18 7.9288e-18
C_x_PM_ISO_FENCE1_X1%A_c1 VSS x_PM_ISO_FENCE1_X1%A_12 1.42747e-17
C_x_PM_ISO_FENCE1_X1%A_c2 VSS N_A_M0_g 7.16235e-17
C_x_PM_ISO_FENCE1_X1%A_c3 VSS N_A_M3_g 3.78496e-17
R_x_PM_ISO_FENCE1_X1%A_r4 x_PM_ISO_FENCE1_X1%A_18 x_PM_ISO_FENCE1_X1%A_14 3.38
R_x_PM_ISO_FENCE1_X1%A_r5 x_PM_ISO_FENCE1_X1%A_14 x_PM_ISO_FENCE1_X1%A_12 25.0012
R_x_PM_ISO_FENCE1_X1%A_r6 x_PM_ISO_FENCE1_X1%A_12 A 0.115357
R_x_PM_ISO_FENCE1_X1%A_r7 x_PM_ISO_FENCE1_X1%A_18 x_PM_ISO_FENCE1_X1%A_5 1.95
R_x_PM_ISO_FENCE1_X1%A_r8 N_A_M0_g x_PM_ISO_FENCE1_X1%A_5 78
R_x_PM_ISO_FENCE1_X1%A_r9 x_PM_ISO_FENCE1_X1%A_18 x_PM_ISO_FENCE1_X1%A_1 1.95
R_x_PM_ISO_FENCE1_X1%A_r10 N_A_M3_g x_PM_ISO_FENCE1_X1%A_1 37.05
C_x_PM_ISO_FENCE1_X1%EN_c0 VSS x_PM_ISO_FENCE1_X1%EN_14 9.25974e-18
C_x_PM_ISO_FENCE1_X1%EN_c1 VSS x_PM_ISO_FENCE1_X1%EN_12 4.3281e-17
C_x_PM_ISO_FENCE1_X1%EN_c2 VSS N_EN_M1_g 5.84051e-17
C_x_PM_ISO_FENCE1_X1%EN_c3 VSS N_EN_M4_g 5.38422e-17
R_x_PM_ISO_FENCE1_X1%EN_r4 x_PM_ISO_FENCE1_X1%EN_18 x_PM_ISO_FENCE1_X1%EN_14 4.7687
R_x_PM_ISO_FENCE1_X1%EN_r5 x_PM_ISO_FENCE1_X1%EN_17 x_PM_ISO_FENCE1_X1%EN_14 4.7687
R_x_PM_ISO_FENCE1_X1%EN_r6 x_PM_ISO_FENCE1_X1%EN_14 x_PM_ISO_FENCE1_X1%EN_12 25.0012
R_x_PM_ISO_FENCE1_X1%EN_r7 x_PM_ISO_FENCE1_X1%EN_12 EN 0.169643
R_x_PM_ISO_FENCE1_X1%EN_r8 N_EN_M1_g x_PM_ISO_FENCE1_X1%EN_18 56.94
R_x_PM_ISO_FENCE1_X1%EN_r9 N_EN_M4_g x_PM_ISO_FENCE1_X1%EN_17 58.11
C_x_PM_ISO_FENCE1_X1%Z_c0 VSS N_Z_M5_d 1.44959e-16
R_x_PM_ISO_FENCE1_X1%Z_r1 N_Z_M2_d Z 1.31944
R_x_PM_ISO_FENCE1_X1%Z_r2 Z N_Z_M5_d 1.57278
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE1_X2.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE1_X2 VDD VSS A EN Z
*.PININFO VDD:P VSS:G A:I EN:I Z:O
*.EQN Z=(A + EN)
M_M3 7 N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.250000U L=0.050000U
M_M4 N_VDD_M1_d N_EN_M1_g 7 VDD PMOS_VTL W=0.250000U L=0.050000U
M_M5 N_Z_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M0 N_3_M3_d N_A_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.155000U L=0.050000U
M_M1 N_VSS_M4_d N_EN_M4_g N_3_M3_d VSS NMOS_VTL W=0.155000U L=0.050000U
M_M2 N_Z_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.305000U L=0.050000U
C_x_PM_ISO_FENCE1_X2%VDD_c0 VSS x_PM_ISO_FENCE1_X2%VDD_35 2.37943e-17
C_x_PM_ISO_FENCE1_X2%VDD_c1 VSS x_PM_ISO_FENCE1_X2%VDD_32 2.93109e-18
C_x_PM_ISO_FENCE1_X2%VDD_c2 VSS x_PM_ISO_FENCE1_X2%VDD_31 1.06425e-17
C_x_PM_ISO_FENCE1_X2%VDD_c3 VSS x_PM_ISO_FENCE1_X2%VDD_30 2.334e-16
C_x_PM_ISO_FENCE1_X2%VDD_c4 VSS x_PM_ISO_FENCE1_X2%VDD_21 2.61519e-16
C_x_PM_ISO_FENCE1_X2%VDD_c5 VSS N_VDD_M1_d 3.52509e-17
C_x_PM_ISO_FENCE1_X2%VDD_c6 VSS x_PM_ISO_FENCE1_X2%VDD_13 4.19334e-17
C_x_PM_ISO_FENCE1_X2%VDD_c7 VSS x_PM_ISO_FENCE1_X2%VDD_12 1.92462e-17
C_x_PM_ISO_FENCE1_X2%VDD_c8 VSS x_PM_ISO_FENCE1_X2%VDD_8 5.77955e-16
R_x_PM_ISO_FENCE1_X2%VDD_r9 x_PM_ISO_FENCE1_X2%VDD_35 VDD 0.13879
R_x_PM_ISO_FENCE1_X2%VDD_r10 x_PM_ISO_FENCE1_X2%VDD_31 VDD 0.138595
R_x_PM_ISO_FENCE1_X2%VDD_r11 x_PM_ISO_FENCE1_X2%VDD_30 VDD 0.138985
R_x_PM_ISO_FENCE1_X2%VDD_r12 x_PM_ISO_FENCE1_X2%VDD_21 VDD 0.13879
R_x_PM_ISO_FENCE1_X2%VDD_r13 VDD x_PM_ISO_FENCE1_X2%VDD_21 3.84471
R_x_PM_ISO_FENCE1_X2%VDD_r14 x_PM_ISO_FENCE1_X2%VDD_32 x_PM_ISO_FENCE1_X2%VDD_20 0.073144
R_x_PM_ISO_FENCE1_X2%VDD_r15 x_PM_ISO_FENCE1_X2%VDD_20 x_PM_ISO_FENCE1_X2%VDD_35 0.659412
R_x_PM_ISO_FENCE1_X2%VDD_r16 x_PM_ISO_FENCE1_X2%VDD_32 x_PM_ISO_FENCE1_X2%VDD_15 0.145286
R_x_PM_ISO_FENCE1_X2%VDD_r17 N_VDD_M1_d x_PM_ISO_FENCE1_X2%VDD_15 0.556429
R_x_PM_ISO_FENCE1_X2%VDD_r18 x_PM_ISO_FENCE1_X2%VDD_32 x_PM_ISO_FENCE1_X2%VDD_13 0.073144
R_x_PM_ISO_FENCE1_X2%VDD_r19 x_PM_ISO_FENCE1_X2%VDD_31 x_PM_ISO_FENCE1_X2%VDD_13 1.08412
R_x_PM_ISO_FENCE1_X2%VDD_r20 VDD x_PM_ISO_FENCE1_X2%VDD_12 0.140282
R_x_PM_ISO_FENCE1_X2%VDD_r21 x_PM_ISO_FENCE1_X2%VDD_12 x_PM_ISO_FENCE1_X2%VDD_30 7.68941
R_x_PM_ISO_FENCE1_X2%VDD_r22 VDD x_PM_ISO_FENCE1_X2%VDD_8 8.94118
C_x_PM_ISO_FENCE1_X2%VSS_c0 VSS x_PM_ISO_FENCE1_X2%VSS_40 2.35261e-17
C_x_PM_ISO_FENCE1_X2%VSS_c1 VSS x_PM_ISO_FENCE1_X2%VSS_37 2.95878e-18
C_x_PM_ISO_FENCE1_X2%VSS_c2 VSS VSS 2.61469e-16
C_x_PM_ISO_FENCE1_X2%VSS_c3 VSS N_VSS_M4_d 3.32781e-17
C_x_PM_ISO_FENCE1_X2%VSS_c4 VSS x_PM_ISO_FENCE1_X2%VSS_19 2.11918e-17
C_x_PM_ISO_FENCE1_X2%VSS_c5 VSS x_PM_ISO_FENCE1_X2%VSS_18 2.18361e-17
C_x_PM_ISO_FENCE1_X2%VSS_c6 VSS N_VSS_M3_s 2.14816e-17
C_x_PM_ISO_FENCE1_X2%VSS_c7 VSS x_PM_ISO_FENCE1_X2%VSS_11 5.77955e-16
C_x_PM_ISO_FENCE1_X2%VSS_c8 VSS x_PM_ISO_FENCE1_X2%VSS_10 1.92462e-17
C_x_PM_ISO_FENCE1_X2%VSS_c9 VSS x_PM_ISO_FENCE1_X2%VSS_9 2.334e-16
R_x_PM_ISO_FENCE1_X2%VSS_r10 x_PM_ISO_FENCE1_X2%VSS_40 VSS 0.13879
R_x_PM_ISO_FENCE1_X2%VSS_r11 x_PM_ISO_FENCE1_X2%VSS_36 VSS 0.457684
R_x_PM_ISO_FENCE1_X2%VSS_r12 x_PM_ISO_FENCE1_X2%VSS_37 x_PM_ISO_FENCE1_X2%VSS_27 0.073144
R_x_PM_ISO_FENCE1_X2%VSS_r13 x_PM_ISO_FENCE1_X2%VSS_27 x_PM_ISO_FENCE1_X2%VSS_40 0.659412
R_x_PM_ISO_FENCE1_X2%VSS_r14 x_PM_ISO_FENCE1_X2%VSS_37 x_PM_ISO_FENCE1_X2%VSS_22 0.145286
R_x_PM_ISO_FENCE1_X2%VSS_r15 N_VSS_M4_d x_PM_ISO_FENCE1_X2%VSS_22 0.936429
R_x_PM_ISO_FENCE1_X2%VSS_r16 x_PM_ISO_FENCE1_X2%VSS_36 x_PM_ISO_FENCE1_X2%VSS_19 0.075426
R_x_PM_ISO_FENCE1_X2%VSS_r17 VSS x_PM_ISO_FENCE1_X2%VSS_19 0.536471
R_x_PM_ISO_FENCE1_X2%VSS_r18 x_PM_ISO_FENCE1_X2%VSS_37 x_PM_ISO_FENCE1_X2%VSS_18 0.073144
R_x_PM_ISO_FENCE1_X2%VSS_r19 VSS x_PM_ISO_FENCE1_X2%VSS_18 0.134118
R_x_PM_ISO_FENCE1_X2%VSS_r20 N_VSS_M3_s x_PM_ISO_FENCE1_X2%VSS_36 0.936429
R_x_PM_ISO_FENCE1_X2%VSS_r21 VSS x_PM_ISO_FENCE1_X2%VSS_11 8.94118
R_x_PM_ISO_FENCE1_X2%VSS_r22 VSS x_PM_ISO_FENCE1_X2%VSS_10 0.140282
R_x_PM_ISO_FENCE1_X2%VSS_r23 VSS x_PM_ISO_FENCE1_X2%VSS_9 0.144058
R_x_PM_ISO_FENCE1_X2%VSS_r24 x_PM_ISO_FENCE1_X2%VSS_10 x_PM_ISO_FENCE1_X2%VSS_9 7.68941
C_x_PM_ISO_FENCE1_X2%3_c0 VSS x_PM_ISO_FENCE1_X2%3_28 1.26908e-17
C_x_PM_ISO_FENCE1_X2%3_c1 VSS x_PM_ISO_FENCE1_X2%3_24 1.27891e-16
C_x_PM_ISO_FENCE1_X2%3_c2 VSS x_PM_ISO_FENCE1_X2%3_20 9.4783e-18
C_x_PM_ISO_FENCE1_X2%3_c3 VSS x_PM_ISO_FENCE1_X2%3_19 3.64601e-17
C_x_PM_ISO_FENCE1_X2%3_c4 VSS N_3_M3_d 3.56094e-17
C_x_PM_ISO_FENCE1_X2%3_c5 VSS x_PM_ISO_FENCE1_X2%3_11 7.77689e-17
C_x_PM_ISO_FENCE1_X2%3_c6 VSS N_3_M2_g 6.76617e-17
C_x_PM_ISO_FENCE1_X2%3_c7 VSS N_3_M5_g 4.48433e-17
R_x_PM_ISO_FENCE1_X2%3_r8 x_PM_ISO_FENCE1_X2%3_28 x_PM_ISO_FENCE1_X2%3_26 4.42
R_x_PM_ISO_FENCE1_X2%3_r9 x_PM_ISO_FENCE1_X2%3_26 x_PM_ISO_FENCE1_X2%3_24 25.0012
R_x_PM_ISO_FENCE1_X2%3_r10 x_PM_ISO_FENCE1_X2%3_24 x_PM_ISO_FENCE1_X2%3_22 2.15786
R_x_PM_ISO_FENCE1_X2%3_r11 x_PM_ISO_FENCE1_X2%3_24 x_PM_ISO_FENCE1_X2%3_21 0.583571
R_x_PM_ISO_FENCE1_X2%3_r12 x_PM_ISO_FENCE1_X2%3_21 x_PM_ISO_FENCE1_X2%3_19 0.212317
R_x_PM_ISO_FENCE1_X2%3_r13 x_PM_ISO_FENCE1_X2%3_20 x_PM_ISO_FENCE1_X2%3_19 0.895714
R_x_PM_ISO_FENCE1_X2%3_r14 x_PM_ISO_FENCE1_X2%3_20 x_PM_ISO_FENCE1_X2%3_15 0.212317
R_x_PM_ISO_FENCE1_X2%3_r15 N_3_M3_d x_PM_ISO_FENCE1_X2%3_15 0.773571
R_x_PM_ISO_FENCE1_X2%3_r16 x_PM_ISO_FENCE1_X2%3_22 x_PM_ISO_FENCE1_X2%3_11 0.212317
R_x_PM_ISO_FENCE1_X2%3_r17 N_3_M0_s x_PM_ISO_FENCE1_X2%3_11 2.13071
R_x_PM_ISO_FENCE1_X2%3_r18 x_PM_ISO_FENCE1_X2%3_28 x_PM_ISO_FENCE1_X2%3_5 1.95
R_x_PM_ISO_FENCE1_X2%3_r19 N_3_M2_g x_PM_ISO_FENCE1_X2%3_5 61.23
R_x_PM_ISO_FENCE1_X2%3_r20 x_PM_ISO_FENCE1_X2%3_28 x_PM_ISO_FENCE1_X2%3_1 1.95
R_x_PM_ISO_FENCE1_X2%3_r21 N_3_M5_g x_PM_ISO_FENCE1_X2%3_1 31.59
C_x_PM_ISO_FENCE1_X2%A_c0 VSS x_PM_ISO_FENCE1_X2%A_18 8.60294e-18
C_x_PM_ISO_FENCE1_X2%A_c1 VSS x_PM_ISO_FENCE1_X2%A_12 1.51045e-17
C_x_PM_ISO_FENCE1_X2%A_c2 VSS N_A_M0_g 6.1244e-17
C_x_PM_ISO_FENCE1_X2%A_c3 VSS N_A_M3_g 4.21759e-17
R_x_PM_ISO_FENCE1_X2%A_r4 x_PM_ISO_FENCE1_X2%A_18 x_PM_ISO_FENCE1_X2%A_14 4.42
R_x_PM_ISO_FENCE1_X2%A_r5 x_PM_ISO_FENCE1_X2%A_14 x_PM_ISO_FENCE1_X2%A_12 25.0012
R_x_PM_ISO_FENCE1_X2%A_r6 x_PM_ISO_FENCE1_X2%A_12 A 0.156071
R_x_PM_ISO_FENCE1_X2%A_r7 x_PM_ISO_FENCE1_X2%A_18 x_PM_ISO_FENCE1_X2%A_5 1.95
R_x_PM_ISO_FENCE1_X2%A_r8 N_A_M0_g x_PM_ISO_FENCE1_X2%A_5 71.76
R_x_PM_ISO_FENCE1_X2%A_r9 x_PM_ISO_FENCE1_X2%A_18 x_PM_ISO_FENCE1_X2%A_1 1.95
R_x_PM_ISO_FENCE1_X2%A_r10 N_A_M3_g x_PM_ISO_FENCE1_X2%A_1 45.63
C_x_PM_ISO_FENCE1_X2%EN_c0 VSS x_PM_ISO_FENCE1_X2%EN_14 8.40838e-18
C_x_PM_ISO_FENCE1_X2%EN_c1 VSS x_PM_ISO_FENCE1_X2%EN_12 4.12859e-17
C_x_PM_ISO_FENCE1_X2%EN_c2 VSS N_EN_M1_g 5.32346e-17
C_x_PM_ISO_FENCE1_X2%EN_c3 VSS N_EN_M4_g 5.99512e-17
R_x_PM_ISO_FENCE1_X2%EN_r4 x_PM_ISO_FENCE1_X2%EN_18 x_PM_ISO_FENCE1_X2%EN_14 4.7687
R_x_PM_ISO_FENCE1_X2%EN_r5 x_PM_ISO_FENCE1_X2%EN_17 x_PM_ISO_FENCE1_X2%EN_14 4.7687
R_x_PM_ISO_FENCE1_X2%EN_r6 x_PM_ISO_FENCE1_X2%EN_14 x_PM_ISO_FENCE1_X2%EN_12 25.0012
R_x_PM_ISO_FENCE1_X2%EN_r7 x_PM_ISO_FENCE1_X2%EN_12 EN 0.2375
R_x_PM_ISO_FENCE1_X2%EN_r8 N_EN_M1_g x_PM_ISO_FENCE1_X2%EN_18 49.92
R_x_PM_ISO_FENCE1_X2%EN_r9 N_EN_M4_g x_PM_ISO_FENCE1_X2%EN_17 67.47
C_x_PM_ISO_FENCE1_X2%Z_c0 VSS N_Z_M5_d 1.48466e-16
R_x_PM_ISO_FENCE1_X2%Z_r1 N_Z_M2_d Z 2.07643
R_x_PM_ISO_FENCE1_X2%Z_r2 Z N_Z_M5_d 0.773571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ISO_FENCE1_X4.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:43 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT ISO_FENCE1_X4 VDD VSS A EN Z
*.PININFO VDD:P VSS:G A:I EN:I Z:O
*.EQN Z=(A + EN)
M_M4 7 N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.460000U L=0.050000U
M_M5 N_VDD_M1_d N_EN_M1_g 7 VDD PMOS_VTL W=0.460000U L=0.050000U
M_M6 N_Z_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M7 N_VDD_M3_d N_3_M3_g N_Z_M2_d VDD PMOS_VTL W=0.415000U L=0.050000U
M_M0 N_3_M4_d N_A_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.280000U L=0.050000U
M_M1 N_VSS_M5_d N_EN_M5_g N_3_M4_d VSS NMOS_VTL W=0.280000U L=0.050000U
M_M2 N_Z_M6_d N_3_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.305000U L=0.050000U
M_M3 N_VSS_M7_d N_3_M7_g N_Z_M6_d VSS NMOS_VTL W=0.305000U L=0.050000U
C_x_PM_ISO_FENCE1_X4%VDD_c0 VSS x_PM_ISO_FENCE1_X4%VDD_37 2.90088e-18
C_x_PM_ISO_FENCE1_X4%VDD_c1 VSS x_PM_ISO_FENCE1_X4%VDD_36 1.07541e-17
C_x_PM_ISO_FENCE1_X4%VDD_c2 VSS x_PM_ISO_FENCE1_X4%VDD_35 2.334e-16
C_x_PM_ISO_FENCE1_X4%VDD_c3 VSS x_PM_ISO_FENCE1_X4%VDD_26 2.73197e-16
C_x_PM_ISO_FENCE1_X4%VDD_c4 VSS N_VDD_M3_d 2.89798e-17
C_x_PM_ISO_FENCE1_X4%VDD_c5 VSS x_PM_ISO_FENCE1_X4%VDD_20 2.17779e-17
C_x_PM_ISO_FENCE1_X4%VDD_c6 VSS N_VDD_M1_d 3.65168e-17
C_x_PM_ISO_FENCE1_X4%VDD_c7 VSS x_PM_ISO_FENCE1_X4%VDD_14 3.72673e-17
C_x_PM_ISO_FENCE1_X4%VDD_c8 VSS x_PM_ISO_FENCE1_X4%VDD_13 1.92462e-17
C_x_PM_ISO_FENCE1_X4%VDD_c9 VSS x_PM_ISO_FENCE1_X4%VDD_9 5.90809e-16
R_x_PM_ISO_FENCE1_X4%VDD_r10 VDD x_PM_ISO_FENCE1_X4%VDD_38 0.490833
R_x_PM_ISO_FENCE1_X4%VDD_r11 x_PM_ISO_FENCE1_X4%VDD_36 VDD 0.138595
R_x_PM_ISO_FENCE1_X4%VDD_r12 x_PM_ISO_FENCE1_X4%VDD_35 VDD 0.138985
R_x_PM_ISO_FENCE1_X4%VDD_r13 VDD x_PM_ISO_FENCE1_X4%VDD_26 0.144103
R_x_PM_ISO_FENCE1_X4%VDD_r14 VDD x_PM_ISO_FENCE1_X4%VDD_26 3.84471
R_x_PM_ISO_FENCE1_X4%VDD_r15 N_VDD_M3_d x_PM_ISO_FENCE1_X4%VDD_38 0.610714
R_x_PM_ISO_FENCE1_X4%VDD_r16 x_PM_ISO_FENCE1_X4%VDD_37 x_PM_ISO_FENCE1_X4%VDD_21 0.073144
R_x_PM_ISO_FENCE1_X4%VDD_r17 x_PM_ISO_FENCE1_X4%VDD_38 x_PM_ISO_FENCE1_X4%VDD_20 0.075492
R_x_PM_ISO_FENCE1_X4%VDD_r18 x_PM_ISO_FENCE1_X4%VDD_21 x_PM_ISO_FENCE1_X4%VDD_20 0.692941
R_x_PM_ISO_FENCE1_X4%VDD_r19 x_PM_ISO_FENCE1_X4%VDD_37 x_PM_ISO_FENCE1_X4%VDD_16 0.145286
R_x_PM_ISO_FENCE1_X4%VDD_r20 N_VDD_M1_d x_PM_ISO_FENCE1_X4%VDD_16 0.610714
R_x_PM_ISO_FENCE1_X4%VDD_r21 x_PM_ISO_FENCE1_X4%VDD_37 x_PM_ISO_FENCE1_X4%VDD_14 0.073144
R_x_PM_ISO_FENCE1_X4%VDD_r22 x_PM_ISO_FENCE1_X4%VDD_36 x_PM_ISO_FENCE1_X4%VDD_14 1.02824
R_x_PM_ISO_FENCE1_X4%VDD_r23 VDD x_PM_ISO_FENCE1_X4%VDD_13 0.140282
R_x_PM_ISO_FENCE1_X4%VDD_r24 x_PM_ISO_FENCE1_X4%VDD_13 x_PM_ISO_FENCE1_X4%VDD_35 7.68941
R_x_PM_ISO_FENCE1_X4%VDD_r25 VDD x_PM_ISO_FENCE1_X4%VDD_9 9.15353
C_x_PM_ISO_FENCE1_X4%VSS_c0 VSS VSS 2.73114e-16
C_x_PM_ISO_FENCE1_X4%VSS_c1 VSS x_PM_ISO_FENCE1_X4%VSS_42 2.7779e-18
C_x_PM_ISO_FENCE1_X4%VSS_c2 VSS N_VSS_M7_d 3.35624e-17
C_x_PM_ISO_FENCE1_X4%VSS_c3 VSS x_PM_ISO_FENCE1_X4%VSS_27 4.2276e-17
C_x_PM_ISO_FENCE1_X4%VSS_c4 VSS VSS 2.45028e-17
C_x_PM_ISO_FENCE1_X4%VSS_c5 VSS x_PM_ISO_FENCE1_X4%VSS_20 1.90479e-17
C_x_PM_ISO_FENCE1_X4%VSS_c6 VSS x_PM_ISO_FENCE1_X4%VSS_19 3.10176e-17
C_x_PM_ISO_FENCE1_X4%VSS_c7 VSS N_VSS_M4_s 3.4333e-17
C_x_PM_ISO_FENCE1_X4%VSS_c8 VSS x_PM_ISO_FENCE1_X4%VSS_12 5.90809e-16
C_x_PM_ISO_FENCE1_X4%VSS_c9 VSS x_PM_ISO_FENCE1_X4%VSS_11 1.92462e-17
C_x_PM_ISO_FENCE1_X4%VSS_c10 VSS x_PM_ISO_FENCE1_X4%VSS_10 2.334e-16
R_x_PM_ISO_FENCE1_X4%VSS_r11 VSS x_PM_ISO_FENCE1_X4%VSS_43 0.490833
R_x_PM_ISO_FENCE1_X4%VSS_r12 x_PM_ISO_FENCE1_X4%VSS_41 VSS 0.392137
R_x_PM_ISO_FENCE1_X4%VSS_r13 N_VSS_M7_d x_PM_ISO_FENCE1_X4%VSS_43 1.09929
R_x_PM_ISO_FENCE1_X4%VSS_r14 x_PM_ISO_FENCE1_X4%VSS_42 x_PM_ISO_FENCE1_X4%VSS_28 0.073144
R_x_PM_ISO_FENCE1_X4%VSS_r15 x_PM_ISO_FENCE1_X4%VSS_43 x_PM_ISO_FENCE1_X4%VSS_27 0.075492
R_x_PM_ISO_FENCE1_X4%VSS_r16 x_PM_ISO_FENCE1_X4%VSS_28 x_PM_ISO_FENCE1_X4%VSS_27 0.692941
R_x_PM_ISO_FENCE1_X4%VSS_r17 N_VSS_M5_d VSS 0.067857
R_x_PM_ISO_FENCE1_X4%VSS_r18 x_PM_ISO_FENCE1_X4%VSS_42 x_PM_ISO_FENCE1_X4%VSS_21 0.145286
R_x_PM_ISO_FENCE1_X4%VSS_r19 VSS x_PM_ISO_FENCE1_X4%VSS_21 0.271429
R_x_PM_ISO_FENCE1_X4%VSS_r20 x_PM_ISO_FENCE1_X4%VSS_41 x_PM_ISO_FENCE1_X4%VSS_20 0.0753
R_x_PM_ISO_FENCE1_X4%VSS_r21 x_PM_ISO_FENCE1_X4%VSS_42 x_PM_ISO_FENCE1_X4%VSS_19 0.073144
R_x_PM_ISO_FENCE1_X4%VSS_r22 x_PM_ISO_FENCE1_X4%VSS_20 x_PM_ISO_FENCE1_X4%VSS_19 0.681765
R_x_PM_ISO_FENCE1_X4%VSS_r23 N_VSS_M4_s x_PM_ISO_FENCE1_X4%VSS_41 1.09929
R_x_PM_ISO_FENCE1_X4%VSS_r24 VSS x_PM_ISO_FENCE1_X4%VSS_12 9.15353
R_x_PM_ISO_FENCE1_X4%VSS_r25 VSS x_PM_ISO_FENCE1_X4%VSS_11 0.140282
R_x_PM_ISO_FENCE1_X4%VSS_r26 VSS x_PM_ISO_FENCE1_X4%VSS_10 0.143516
R_x_PM_ISO_FENCE1_X4%VSS_r27 x_PM_ISO_FENCE1_X4%VSS_11 x_PM_ISO_FENCE1_X4%VSS_10 7.68941
C_x_PM_ISO_FENCE1_X4%3_c0 VSS x_PM_ISO_FENCE1_X4%3_35 9.05496e-17
C_x_PM_ISO_FENCE1_X4%3_c1 VSS x_PM_ISO_FENCE1_X4%3_28 7.82856e-17
C_x_PM_ISO_FENCE1_X4%3_c2 VSS x_PM_ISO_FENCE1_X4%3_27 6.99878e-18
C_x_PM_ISO_FENCE1_X4%3_c3 VSS x_PM_ISO_FENCE1_X4%3_26 5.06457e-17
C_x_PM_ISO_FENCE1_X4%3_c4 VSS N_3_M0_s 2.50606e-17
C_x_PM_ISO_FENCE1_X4%3_c5 VSS x_PM_ISO_FENCE1_X4%3_19 3.30952e-18
C_x_PM_ISO_FENCE1_X4%3_c6 VSS N_3_M3_g 5.24093e-17
C_x_PM_ISO_FENCE1_X4%3_c7 VSS N_3_M7_g 3.85077e-17
C_x_PM_ISO_FENCE1_X4%3_c8 VSS x_PM_ISO_FENCE1_X4%3_10 7.16207e-18
C_x_PM_ISO_FENCE1_X4%3_c9 VSS x_PM_ISO_FENCE1_X4%3_9 1.26095e-17
C_x_PM_ISO_FENCE1_X4%3_c10 VSS N_3_M2_g 4.88809e-17
C_x_PM_ISO_FENCE1_X4%3_c11 VSS N_3_M6_g 3.20174e-17
R_x_PM_ISO_FENCE1_X4%3_r12 x_PM_ISO_FENCE1_X4%3_39 x_PM_ISO_FENCE1_X4%3_37 3.9
R_x_PM_ISO_FENCE1_X4%3_r13 x_PM_ISO_FENCE1_X4%3_37 x_PM_ISO_FENCE1_X4%3_35 25.0012
R_x_PM_ISO_FENCE1_X4%3_r14 x_PM_ISO_FENCE1_X4%3_35 x_PM_ISO_FENCE1_X4%3_33 0.963571
R_x_PM_ISO_FENCE1_X4%3_r15 x_PM_ISO_FENCE1_X4%3_35 x_PM_ISO_FENCE1_X4%3_32 1.01786
R_x_PM_ISO_FENCE1_X4%3_r16 x_PM_ISO_FENCE1_X4%3_32 x_PM_ISO_FENCE1_X4%3_28 0.212317
R_x_PM_ISO_FENCE1_X4%3_r17 N_3_M4_d x_PM_ISO_FENCE1_X4%3_28 1.12643
R_x_PM_ISO_FENCE1_X4%3_r18 x_PM_ISO_FENCE1_X4%3_33 x_PM_ISO_FENCE1_X4%3_26 0.212317
R_x_PM_ISO_FENCE1_X4%3_r19 x_PM_ISO_FENCE1_X4%3_27 x_PM_ISO_FENCE1_X4%3_26 1.95429
R_x_PM_ISO_FENCE1_X4%3_r20 x_PM_ISO_FENCE1_X4%3_27 x_PM_ISO_FENCE1_X4%3_22 0.212317
R_x_PM_ISO_FENCE1_X4%3_r21 N_3_M0_s x_PM_ISO_FENCE1_X4%3_22 1.20786
R_x_PM_ISO_FENCE1_X4%3_r22 x_PM_ISO_FENCE1_X4%3_19 x_PM_ISO_FENCE1_X4%3_15 4.56151
R_x_PM_ISO_FENCE1_X4%3_r23 N_3_M3_g x_PM_ISO_FENCE1_X4%3_15 70.59
R_x_PM_ISO_FENCE1_X4%3_r24 x_PM_ISO_FENCE1_X4%3_19 x_PM_ISO_FENCE1_X4%3_11 4.56151
R_x_PM_ISO_FENCE1_X4%3_r25 N_3_M7_g x_PM_ISO_FENCE1_X4%3_11 37.83
R_x_PM_ISO_FENCE1_X4%3_r26 x_PM_ISO_FENCE1_X4%3_39 x_PM_ISO_FENCE1_X4%3_10 2.6
R_x_PM_ISO_FENCE1_X4%3_r27 x_PM_ISO_FENCE1_X4%3_19 x_PM_ISO_FENCE1_X4%3_9 0.043368
R_x_PM_ISO_FENCE1_X4%3_r28 x_PM_ISO_FENCE1_X4%3_10 x_PM_ISO_FENCE1_X4%3_9 14.56
R_x_PM_ISO_FENCE1_X4%3_r29 x_PM_ISO_FENCE1_X4%3_39 x_PM_ISO_FENCE1_X4%3_5 1.95
R_x_PM_ISO_FENCE1_X4%3_r30 N_3_M2_g x_PM_ISO_FENCE1_X4%3_5 70.59
R_x_PM_ISO_FENCE1_X4%3_r31 x_PM_ISO_FENCE1_X4%3_39 x_PM_ISO_FENCE1_X4%3_1 1.95
R_x_PM_ISO_FENCE1_X4%3_r32 N_3_M6_g x_PM_ISO_FENCE1_X4%3_1 37.83
C_x_PM_ISO_FENCE1_X4%A_c0 VSS x_PM_ISO_FENCE1_X4%A_14 7.37455e-18
C_x_PM_ISO_FENCE1_X4%A_c1 VSS x_PM_ISO_FENCE1_X4%A_12 4.76385e-17
C_x_PM_ISO_FENCE1_X4%A_c2 VSS N_A_M0_g 8.44835e-17
C_x_PM_ISO_FENCE1_X4%A_c3 VSS N_A_M4_g 4.43993e-17
R_x_PM_ISO_FENCE1_X4%A_r4 x_PM_ISO_FENCE1_X4%A_18 x_PM_ISO_FENCE1_X4%A_14 4.74714
R_x_PM_ISO_FENCE1_X4%A_r5 x_PM_ISO_FENCE1_X4%A_17 x_PM_ISO_FENCE1_X4%A_14 4.74714
R_x_PM_ISO_FENCE1_X4%A_r6 x_PM_ISO_FENCE1_X4%A_14 x_PM_ISO_FENCE1_X4%A_12 25.0012
R_x_PM_ISO_FENCE1_X4%A_r7 x_PM_ISO_FENCE1_X4%A_12 A 0.156071
R_x_PM_ISO_FENCE1_X4%A_r8 N_A_M0_g x_PM_ISO_FENCE1_X4%A_18 82.68
R_x_PM_ISO_FENCE1_X4%A_r9 N_A_M4_g x_PM_ISO_FENCE1_X4%A_17 31.2
C_x_PM_ISO_FENCE1_X4%EN_c0 VSS x_PM_ISO_FENCE1_X4%EN_14 8.77233e-18
C_x_PM_ISO_FENCE1_X4%EN_c1 VSS x_PM_ISO_FENCE1_X4%EN_12 7.34632e-17
C_x_PM_ISO_FENCE1_X4%EN_c2 VSS N_EN_M1_g 8.4143e-17
C_x_PM_ISO_FENCE1_X4%EN_c3 VSS N_EN_M5_g 4.41696e-17
R_x_PM_ISO_FENCE1_X4%EN_r4 x_PM_ISO_FENCE1_X4%EN_18 x_PM_ISO_FENCE1_X4%EN_14 4.7687
R_x_PM_ISO_FENCE1_X4%EN_r5 x_PM_ISO_FENCE1_X4%EN_17 x_PM_ISO_FENCE1_X4%EN_14 4.7687
R_x_PM_ISO_FENCE1_X4%EN_r6 x_PM_ISO_FENCE1_X4%EN_14 x_PM_ISO_FENCE1_X4%EN_12 25.0012
R_x_PM_ISO_FENCE1_X4%EN_r7 x_PM_ISO_FENCE1_X4%EN_12 EN 0.169643
R_x_PM_ISO_FENCE1_X4%EN_r8 N_EN_M1_g x_PM_ISO_FENCE1_X4%EN_18 82.68
R_x_PM_ISO_FENCE1_X4%EN_r9 N_EN_M5_g x_PM_ISO_FENCE1_X4%EN_17 31.2
C_x_PM_ISO_FENCE1_X4%Z_c0 VSS N_Z_M6_d 2.26994e-16
R_x_PM_ISO_FENCE1_X4%Z_r1 N_Z_M2_d Z 1.76278
R_x_PM_ISO_FENCE1_X4%Z_r2 Z N_Z_M6_d 1.15056
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_HLEN_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_HLEN_X1 VDDL VSS A ISOLN Z
*.PININFO VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M3 N_3_M0_d N_A_M0_g N_VDDL_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M4 N_VDDL_M1_d N_ISOLN_M1_g N_3_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M5 N_Z_M2_d N_3_M2_g N_VDDL_M1_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M0 7 N_A_M3_g N_3_M3_s N_VSS_M3_b NMOS_VTL L=5e-08 W=1.8e-07
M_M1 N_VSS_M4_d N_ISOLN_M4_g 7 N_VSS_M3_b NMOS_VTL L=5e-08 W=1.8e-07
M_M2 N_Z_M5_d N_3_M5_g N_VSS_M4_d N_VSS_M3_b NMOS_VTL L=5e-08 W=1.55e-07
C_x_PM_LS_HLEN_X1%VDDL_c0 x_PM_LS_HLEN_X1%VDDL_50 VSS 0.00295132f
C_x_PM_LS_HLEN_X1%VDDL_c1 x_PM_LS_HLEN_X1%VDDL_49 VSS 0.00301185f
C_x_PM_LS_HLEN_X1%VDDL_c2 VDDL VSS 0.254713f
C_x_PM_LS_HLEN_X1%VDDL_c3 x_PM_LS_HLEN_X1%VDDL_37 VSS 0.0207087f
C_x_PM_LS_HLEN_X1%VDDL_c4 N_VDDL_M1_d VSS 0.0453362f
C_x_PM_LS_HLEN_X1%VDDL_c5 x_PM_LS_HLEN_X1%VDDL_32 VSS 0.010254f
C_x_PM_LS_HLEN_X1%VDDL_c6 x_PM_LS_HLEN_X1%VDDL_31 VSS 0.0187699f
C_x_PM_LS_HLEN_X1%VDDL_c7 N_VDDL_M0_s VSS 0.0222633f
C_x_PM_LS_HLEN_X1%VDDL_c8 x_PM_LS_HLEN_X1%VDDL_22 VSS 0.0120441f
C_x_PM_LS_HLEN_X1%VDDL_c9 x_PM_LS_HLEN_X1%VDDL_21 VSS 0.240864f
C_x_PM_LS_HLEN_X1%VDDL_c10 VDDL VSS 0.588991f
C_x_PM_LS_HLEN_X1%VDDL_c11 N_VDDL_M0_b VSS 0.03713f
R_x_PM_LS_HLEN_X1%VDDL_r12 x_PM_LS_HLEN_X1%VDDL_47 x_PM_LS_HLEN_X1%VDDL_48 0.368824
R_x_PM_LS_HLEN_X1%VDDL_r13 x_PM_LS_HLEN_X1%VDDL_43 x_PM_LS_HLEN_X1%VDDL_50 0.0731438
R_x_PM_LS_HLEN_X1%VDDL_r14 x_PM_LS_HLEN_X1%VDDL_43 VDDL 8.03588
R_x_PM_LS_HLEN_X1%VDDL_r15 x_PM_LS_HLEN_X1%VDDL_39 x_PM_LS_HLEN_X1%VDDL_50 0.145286
R_x_PM_LS_HLEN_X1%VDDL_r16 x_PM_LS_HLEN_X1%VDDL_38 x_PM_LS_HLEN_X1%VDDL_49 0.0731438
R_x_PM_LS_HLEN_X1%VDDL_r17 x_PM_LS_HLEN_X1%VDDL_37 x_PM_LS_HLEN_X1%VDDL_50 0.0731438
R_x_PM_LS_HLEN_X1%VDDL_r18 x_PM_LS_HLEN_X1%VDDL_37 x_PM_LS_HLEN_X1%VDDL_38 0.737647
R_x_PM_LS_HLEN_X1%VDDL_r19 x_PM_LS_HLEN_X1%VDDL_33 x_PM_LS_HLEN_X1%VDDL_49 0.145286
R_x_PM_LS_HLEN_X1%VDDL_r20 x_PM_LS_HLEN_X1%VDDL_33 N_VDDL_M1_d 1.85929
R_x_PM_LS_HLEN_X1%VDDL_r21 x_PM_LS_HLEN_X1%VDDL_32 x_PM_LS_HLEN_X1%VDDL_48 0.0782353
R_x_PM_LS_HLEN_X1%VDDL_r22 x_PM_LS_HLEN_X1%VDDL_31 x_PM_LS_HLEN_X1%VDDL_49 0.0731438
R_x_PM_LS_HLEN_X1%VDDL_r23 x_PM_LS_HLEN_X1%VDDL_31 x_PM_LS_HLEN_X1%VDDL_32 0.681765
R_x_PM_LS_HLEN_X1%VDDL_r24 x_PM_LS_HLEN_X1%VDDL_27 x_PM_LS_HLEN_X1%VDDL_48 0.095
R_x_PM_LS_HLEN_X1%VDDL_r25 x_PM_LS_HLEN_X1%VDDL_27 N_VDDL_M0_s 1.85929
R_x_PM_LS_HLEN_X1%VDDL_r26 x_PM_LS_HLEN_X1%VDDL_23 x_PM_LS_HLEN_X1%VDDL_47 0.095
R_x_PM_LS_HLEN_X1%VDDL_r27 x_PM_LS_HLEN_X1%VDDL_21 x_PM_LS_HLEN_X1%VDDL_47 0.0782353
R_x_PM_LS_HLEN_X1%VDDL_r28 x_PM_LS_HLEN_X1%VDDL_21 x_PM_LS_HLEN_X1%VDDL_22 7.93529
R_x_PM_LS_HLEN_X1%VDDL_r29 x_PM_LS_HLEN_X1%VDDL_13 x_PM_LS_HLEN_X1%VDDL_22 0.264221
R_x_PM_LS_HLEN_X1%VDDL_r30 x_PM_LS_HLEN_X1%VDDL_39 N_VDDL_M0_b 0.827857
R_x_PM_LS_HLEN_X1%VDDL_r31 x_PM_LS_HLEN_X1%VDDL_23 N_VDDL_M0_b 0.827857
R_x_PM_LS_HLEN_X1%VDDL_r32 x_PM_LS_HLEN_X1%VDDL_13 N_VDDL_M0_b 0.827857
C_x_PM_LS_HLEN_X1%VSS_c0 x_PM_LS_HLEN_X1%VSS_44 VSS 0.25764f
C_x_PM_LS_HLEN_X1%VSS_c1 x_PM_LS_HLEN_X1%VSS_43 VSS 0.00280728f
C_x_PM_LS_HLEN_X1%VSS_c2 x_PM_LS_HLEN_X1%VSS_42 VSS 0.00292673f
C_x_PM_LS_HLEN_X1%VSS_c3 x_PM_LS_HLEN_X1%VSS_34 VSS 0.0323875f
C_x_PM_LS_HLEN_X1%VSS_c4 N_VSS_M4_d VSS 0.027379f
C_x_PM_LS_HLEN_X1%VSS_c5 x_PM_LS_HLEN_X1%VSS_26 VSS 0.0440751f
C_x_PM_LS_HLEN_X1%VSS_c6 N_VSS_M3_b VSS 0.0410102f
C_x_PM_LS_HLEN_X1%VSS_c7 VSS VSS 0.562466f
C_x_PM_LS_HLEN_X1%VSS_c8 x_PM_LS_HLEN_X1%VSS_18 VSS 0.011992f
C_x_PM_LS_HLEN_X1%VSS_c9 x_PM_LS_HLEN_X1%VSS_17 VSS 0.0120195f
C_x_PM_LS_HLEN_X1%VSS_c10 x_PM_LS_HLEN_X1%VSS_16 VSS 0.240864f
C_x_PM_LS_HLEN_X1%VSS_c11 x_PM_LS_HLEN_X1%VSS_12 VSS 0.0110902f
R_x_PM_LS_HLEN_X1%VSS_r12 x_PM_LS_HLEN_X1%VSS_36 x_PM_LS_HLEN_X1%VSS_44 0.145286
R_x_PM_LS_HLEN_X1%VSS_r13 x_PM_LS_HLEN_X1%VSS_35 x_PM_LS_HLEN_X1%VSS_43 0.0731438
R_x_PM_LS_HLEN_X1%VSS_r14 x_PM_LS_HLEN_X1%VSS_34 x_PM_LS_HLEN_X1%VSS_44 0.0731438
R_x_PM_LS_HLEN_X1%VSS_r15 x_PM_LS_HLEN_X1%VSS_34 x_PM_LS_HLEN_X1%VSS_35 0.737647
R_x_PM_LS_HLEN_X1%VSS_r16 x_PM_LS_HLEN_X1%VSS_30 x_PM_LS_HLEN_X1%VSS_43 0.145286
R_x_PM_LS_HLEN_X1%VSS_r17 x_PM_LS_HLEN_X1%VSS_30 N_VSS_M4_d 0.366429
R_x_PM_LS_HLEN_X1%VSS_r18 x_PM_LS_HLEN_X1%VSS_27 x_PM_LS_HLEN_X1%VSS_42 0.0731438
R_x_PM_LS_HLEN_X1%VSS_r19 x_PM_LS_HLEN_X1%VSS_27 VSS 0.972353
R_x_PM_LS_HLEN_X1%VSS_r20 x_PM_LS_HLEN_X1%VSS_26 x_PM_LS_HLEN_X1%VSS_43 0.0731438
R_x_PM_LS_HLEN_X1%VSS_r21 x_PM_LS_HLEN_X1%VSS_26 VSS 0.0782353
R_x_PM_LS_HLEN_X1%VSS_r22 x_PM_LS_HLEN_X1%VSS_36 N_VSS_M3_b 0.502143
R_x_PM_LS_HLEN_X1%VSS_r23 x_PM_LS_HLEN_X1%VSS_22 x_PM_LS_HLEN_X1%VSS_42 0.145286
R_x_PM_LS_HLEN_X1%VSS_r24 x_PM_LS_HLEN_X1%VSS_22 N_VSS_M3_b 0.502143
R_x_PM_LS_HLEN_X1%VSS_r25 x_PM_LS_HLEN_X1%VSS_18 VSS 18.1953
R_x_PM_LS_HLEN_X1%VSS_r26 x_PM_LS_HLEN_X1%VSS_16 x_PM_LS_HLEN_X1%VSS_42 0.0731438
R_x_PM_LS_HLEN_X1%VSS_r27 x_PM_LS_HLEN_X1%VSS_16 x_PM_LS_HLEN_X1%VSS_17 7.93529
R_x_PM_LS_HLEN_X1%VSS_r28 x_PM_LS_HLEN_X1%VSS_12 x_PM_LS_HLEN_X1%VSS_18 0.264221
R_x_PM_LS_HLEN_X1%VSS_r29 x_PM_LS_HLEN_X1%VSS_8 x_PM_LS_HLEN_X1%VSS_17 0.264221
R_x_PM_LS_HLEN_X1%VSS_r30 x_PM_LS_HLEN_X1%VSS_8 N_VSS_M3_b 0.5016
C_x_PM_LS_HLEN_X1%3_c0 x_PM_LS_HLEN_X1%3_30 VSS 0.0123915f
C_x_PM_LS_HLEN_X1%3_c1 x_PM_LS_HLEN_X1%3_26 VSS 0.0995563f
C_x_PM_LS_HLEN_X1%3_c2 x_PM_LS_HLEN_X1%3_22 VSS 0.00833591f
C_x_PM_LS_HLEN_X1%3_c3 x_PM_LS_HLEN_X1%3_21 VSS 0.0396574f
C_x_PM_LS_HLEN_X1%3_c4 N_3_M0_d VSS 0.0172781f
C_x_PM_LS_HLEN_X1%3_c5 x_PM_LS_HLEN_X1%3_16 VSS 0.00547576f
C_x_PM_LS_HLEN_X1%3_c6 x_PM_LS_HLEN_X1%3_15 VSS 0.0785184f
C_x_PM_LS_HLEN_X1%3_c7 N_3_M3_s VSS 0.0185031f
C_x_PM_LS_HLEN_X1%3_c8 N_3_M2_g VSS 0.0524438f
C_x_PM_LS_HLEN_X1%3_c9 N_3_M5_g VSS 0.0490641f
R_x_PM_LS_HLEN_X1%3_r10 x_PM_LS_HLEN_X1%3_28 x_PM_LS_HLEN_X1%3_30 4.42
R_x_PM_LS_HLEN_X1%3_r11 x_PM_LS_HLEN_X1%3_26 x_PM_LS_HLEN_X1%3_28 25.0012
R_x_PM_LS_HLEN_X1%3_r12 x_PM_LS_HLEN_X1%3_24 x_PM_LS_HLEN_X1%3_26 1.235
R_x_PM_LS_HLEN_X1%3_r13 x_PM_LS_HLEN_X1%3_23 x_PM_LS_HLEN_X1%3_26 1.01786
R_x_PM_LS_HLEN_X1%3_r14 x_PM_LS_HLEN_X1%3_21 x_PM_LS_HLEN_X1%3_24 0.212317
R_x_PM_LS_HLEN_X1%3_r15 x_PM_LS_HLEN_X1%3_21 x_PM_LS_HLEN_X1%3_22 0.895714
R_x_PM_LS_HLEN_X1%3_r16 x_PM_LS_HLEN_X1%3_17 x_PM_LS_HLEN_X1%3_22 0.212317
R_x_PM_LS_HLEN_X1%3_r17 x_PM_LS_HLEN_X1%3_17 N_3_M0_d 0.230714
R_x_PM_LS_HLEN_X1%3_r18 x_PM_LS_HLEN_X1%3_15 x_PM_LS_HLEN_X1%3_23 0.212317
R_x_PM_LS_HLEN_X1%3_r19 x_PM_LS_HLEN_X1%3_15 x_PM_LS_HLEN_X1%3_16 1.92714
R_x_PM_LS_HLEN_X1%3_r20 x_PM_LS_HLEN_X1%3_11 x_PM_LS_HLEN_X1%3_16 0.212317
R_x_PM_LS_HLEN_X1%3_r21 x_PM_LS_HLEN_X1%3_11 N_3_M3_s 0.149286
R_x_PM_LS_HLEN_X1%3_r22 x_PM_LS_HLEN_X1%3_5 x_PM_LS_HLEN_X1%3_30 1.95
R_x_PM_LS_HLEN_X1%3_r23 x_PM_LS_HLEN_X1%3_5 N_3_M2_g 51.09
R_x_PM_LS_HLEN_X1%3_r24 x_PM_LS_HLEN_X1%3_1 x_PM_LS_HLEN_X1%3_30 1.95
R_x_PM_LS_HLEN_X1%3_r25 x_PM_LS_HLEN_X1%3_1 N_3_M5_g 48.75
C_x_PM_LS_HLEN_X1%A_c0 x_PM_LS_HLEN_X1%A_14 VSS 0.00700428f
C_x_PM_LS_HLEN_X1%A_c1 x_PM_LS_HLEN_X1%A_12 VSS 0.0160212f
C_x_PM_LS_HLEN_X1%A_c2 N_A_M0_g VSS 0.039216f
C_x_PM_LS_HLEN_X1%A_c3 N_A_M3_g VSS 0.0564162f
R_x_PM_LS_HLEN_X1%A_r4 x_PM_LS_HLEN_X1%A_14 x_PM_LS_HLEN_X1%A_18 4.74714
R_x_PM_LS_HLEN_X1%A_r5 x_PM_LS_HLEN_X1%A_14 x_PM_LS_HLEN_X1%A_17 4.74714
R_x_PM_LS_HLEN_X1%A_r6 x_PM_LS_HLEN_X1%A_12 x_PM_LS_HLEN_X1%A_14 25.0012
R_x_PM_LS_HLEN_X1%A_r7 A x_PM_LS_HLEN_X1%A_12 0.156071
R_x_PM_LS_HLEN_X1%A_r8 x_PM_LS_HLEN_X1%A_18 N_A_M0_g 37.05
R_x_PM_LS_HLEN_X1%A_r9 x_PM_LS_HLEN_X1%A_17 N_A_M3_g 60.84
C_x_PM_LS_HLEN_X1%ISOLN_c0 x_PM_LS_HLEN_X1%ISOLN_14 VSS 0.00873765f
C_x_PM_LS_HLEN_X1%ISOLN_c1 x_PM_LS_HLEN_X1%ISOLN_12 VSS 0.0543175f
C_x_PM_LS_HLEN_X1%ISOLN_c2 N_ISOLN_M1_g VSS 0.0568318f
C_x_PM_LS_HLEN_X1%ISOLN_c3 N_ISOLN_M4_g VSS 0.0425654f
R_x_PM_LS_HLEN_X1%ISOLN_r4 x_PM_LS_HLEN_X1%ISOLN_14 x_PM_LS_HLEN_X1%ISOLN_18 4.7687
R_x_PM_LS_HLEN_X1%ISOLN_r5 x_PM_LS_HLEN_X1%ISOLN_14 x_PM_LS_HLEN_X1%ISOLN_17 4.7687
R_x_PM_LS_HLEN_X1%ISOLN_r6 x_PM_LS_HLEN_X1%ISOLN_12 x_PM_LS_HLEN_X1%ISOLN_14 25.0012
R_x_PM_LS_HLEN_X1%ISOLN_r7 ISOLN x_PM_LS_HLEN_X1%ISOLN_12 0.169643
R_x_PM_LS_HLEN_X1%ISOLN_r8 x_PM_LS_HLEN_X1%ISOLN_18 N_ISOLN_M1_g 59.67
R_x_PM_LS_HLEN_X1%ISOLN_r9 x_PM_LS_HLEN_X1%ISOLN_17 N_ISOLN_M4_g 38.22
C_x_PM_LS_HLEN_X1%Z_c0 N_Z_M5_d VSS 0.161774f
R_x_PM_LS_HLEN_X1%Z_r1 Z N_Z_M2_d 1.27722
R_x_PM_LS_HLEN_X1%Z_r2 N_Z_M5_d Z 1.67833
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_HLEN_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_HLEN_X2 VDDL VSS A ISOLN Z
*.PININFO VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M3 N_3_M0_d N_A_M0_g N_VDDL_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M4 N_VDDL_M1_d N_ISOLN_M1_g N_3_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M5 N_Z_M2_d N_3_M2_g N_VDDL_M1_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=4.15e-07
M_M0 7 N_A_M3_g N_3_M3_s N_VSS_M3_b NMOS_VTL L=5e-08 W=1.8e-07
M_M1 N_VSS_M4_d N_ISOLN_M4_g 7 N_VSS_M3_b NMOS_VTL L=5e-08 W=1.8e-07
M_M2 N_Z_M5_d N_3_M5_g N_VSS_M4_d N_VSS_M3_b NMOS_VTL L=5e-08 W=3.05e-07
C_x_PM_LS_HLEN_X2%VDDL_c0 x_PM_LS_HLEN_X2%VDDL_50 VSS 0.00295132f
C_x_PM_LS_HLEN_X2%VDDL_c1 x_PM_LS_HLEN_X2%VDDL_49 VSS 0.00298731f
C_x_PM_LS_HLEN_X2%VDDL_c2 VDDL VSS 0.254713f
C_x_PM_LS_HLEN_X2%VDDL_c3 x_PM_LS_HLEN_X2%VDDL_37 VSS 0.0205979f
C_x_PM_LS_HLEN_X2%VDDL_c4 N_VDDL_M1_d VSS 0.0208352f
C_x_PM_LS_HLEN_X2%VDDL_c5 x_PM_LS_HLEN_X2%VDDL_32 VSS 0.0102295f
C_x_PM_LS_HLEN_X2%VDDL_c6 x_PM_LS_HLEN_X2%VDDL_31 VSS 0.0190196f
C_x_PM_LS_HLEN_X2%VDDL_c7 N_VDDL_M0_s VSS 0.0147941f
C_x_PM_LS_HLEN_X2%VDDL_c8 x_PM_LS_HLEN_X2%VDDL_22 VSS 0.0120441f
C_x_PM_LS_HLEN_X2%VDDL_c9 x_PM_LS_HLEN_X2%VDDL_21 VSS 0.240864f
C_x_PM_LS_HLEN_X2%VDDL_c10 VDDL VSS 0.588991f
C_x_PM_LS_HLEN_X2%VDDL_c11 N_VDDL_M0_b VSS 0.0374152f
R_x_PM_LS_HLEN_X2%VDDL_r12 x_PM_LS_HLEN_X2%VDDL_47 x_PM_LS_HLEN_X2%VDDL_48 0.368824
R_x_PM_LS_HLEN_X2%VDDL_r13 x_PM_LS_HLEN_X2%VDDL_43 x_PM_LS_HLEN_X2%VDDL_50 0.0731438
R_x_PM_LS_HLEN_X2%VDDL_r14 x_PM_LS_HLEN_X2%VDDL_43 VDDL 8.03588
R_x_PM_LS_HLEN_X2%VDDL_r15 x_PM_LS_HLEN_X2%VDDL_39 x_PM_LS_HLEN_X2%VDDL_50 0.145286
R_x_PM_LS_HLEN_X2%VDDL_r16 x_PM_LS_HLEN_X2%VDDL_38 x_PM_LS_HLEN_X2%VDDL_49 0.0731438
R_x_PM_LS_HLEN_X2%VDDL_r17 x_PM_LS_HLEN_X2%VDDL_37 x_PM_LS_HLEN_X2%VDDL_50 0.0731438
R_x_PM_LS_HLEN_X2%VDDL_r18 x_PM_LS_HLEN_X2%VDDL_37 x_PM_LS_HLEN_X2%VDDL_38 0.737647
R_x_PM_LS_HLEN_X2%VDDL_r19 x_PM_LS_HLEN_X2%VDDL_33 x_PM_LS_HLEN_X2%VDDL_49 0.145286
R_x_PM_LS_HLEN_X2%VDDL_r20 x_PM_LS_HLEN_X2%VDDL_33 N_VDDL_M1_d 1.39786
R_x_PM_LS_HLEN_X2%VDDL_r21 x_PM_LS_HLEN_X2%VDDL_32 x_PM_LS_HLEN_X2%VDDL_48 0.0782353
R_x_PM_LS_HLEN_X2%VDDL_r22 x_PM_LS_HLEN_X2%VDDL_31 x_PM_LS_HLEN_X2%VDDL_49 0.0731438
R_x_PM_LS_HLEN_X2%VDDL_r23 x_PM_LS_HLEN_X2%VDDL_31 x_PM_LS_HLEN_X2%VDDL_32 0.681765
R_x_PM_LS_HLEN_X2%VDDL_r24 x_PM_LS_HLEN_X2%VDDL_27 x_PM_LS_HLEN_X2%VDDL_48 0.095
R_x_PM_LS_HLEN_X2%VDDL_r25 x_PM_LS_HLEN_X2%VDDL_27 N_VDDL_M0_s 1.39786
R_x_PM_LS_HLEN_X2%VDDL_r26 x_PM_LS_HLEN_X2%VDDL_23 x_PM_LS_HLEN_X2%VDDL_47 0.095
R_x_PM_LS_HLEN_X2%VDDL_r27 x_PM_LS_HLEN_X2%VDDL_21 x_PM_LS_HLEN_X2%VDDL_47 0.0782353
R_x_PM_LS_HLEN_X2%VDDL_r28 x_PM_LS_HLEN_X2%VDDL_21 x_PM_LS_HLEN_X2%VDDL_22 7.93529
R_x_PM_LS_HLEN_X2%VDDL_r29 x_PM_LS_HLEN_X2%VDDL_13 x_PM_LS_HLEN_X2%VDDL_22 0.264221
R_x_PM_LS_HLEN_X2%VDDL_r30 x_PM_LS_HLEN_X2%VDDL_39 N_VDDL_M0_b 0.827857
R_x_PM_LS_HLEN_X2%VDDL_r31 x_PM_LS_HLEN_X2%VDDL_23 N_VDDL_M0_b 0.827857
R_x_PM_LS_HLEN_X2%VDDL_r32 x_PM_LS_HLEN_X2%VDDL_13 N_VDDL_M0_b 0.827857
C_x_PM_LS_HLEN_X2%VSS_c0 x_PM_LS_HLEN_X2%VSS_44 VSS 0.25764f
C_x_PM_LS_HLEN_X2%VSS_c1 x_PM_LS_HLEN_X2%VSS_43 VSS 0.00280728f
C_x_PM_LS_HLEN_X2%VSS_c2 x_PM_LS_HLEN_X2%VSS_42 VSS 0.00292673f
C_x_PM_LS_HLEN_X2%VSS_c3 x_PM_LS_HLEN_X2%VSS_34 VSS 0.030447f
C_x_PM_LS_HLEN_X2%VSS_c4 N_VSS_M4_d VSS 0.0268264f
C_x_PM_LS_HLEN_X2%VSS_c5 x_PM_LS_HLEN_X2%VSS_26 VSS 0.044086f
C_x_PM_LS_HLEN_X2%VSS_c6 N_VSS_M3_b VSS 0.0403511f
C_x_PM_LS_HLEN_X2%VSS_c7 VSS VSS 0.562466f
C_x_PM_LS_HLEN_X2%VSS_c8 x_PM_LS_HLEN_X2%VSS_18 VSS 0.011992f
C_x_PM_LS_HLEN_X2%VSS_c9 x_PM_LS_HLEN_X2%VSS_17 VSS 0.0120195f
C_x_PM_LS_HLEN_X2%VSS_c10 x_PM_LS_HLEN_X2%VSS_16 VSS 0.240864f
C_x_PM_LS_HLEN_X2%VSS_c11 x_PM_LS_HLEN_X2%VSS_12 VSS 0.0110902f
R_x_PM_LS_HLEN_X2%VSS_r12 x_PM_LS_HLEN_X2%VSS_36 x_PM_LS_HLEN_X2%VSS_44 0.145286
R_x_PM_LS_HLEN_X2%VSS_r13 x_PM_LS_HLEN_X2%VSS_35 x_PM_LS_HLEN_X2%VSS_43 0.0731438
R_x_PM_LS_HLEN_X2%VSS_r14 x_PM_LS_HLEN_X2%VSS_34 x_PM_LS_HLEN_X2%VSS_44 0.0731438
R_x_PM_LS_HLEN_X2%VSS_r15 x_PM_LS_HLEN_X2%VSS_34 x_PM_LS_HLEN_X2%VSS_35 0.737647
R_x_PM_LS_HLEN_X2%VSS_r16 x_PM_LS_HLEN_X2%VSS_30 x_PM_LS_HLEN_X2%VSS_43 0.145286
R_x_PM_LS_HLEN_X2%VSS_r17 x_PM_LS_HLEN_X2%VSS_30 N_VSS_M4_d 0.366429
R_x_PM_LS_HLEN_X2%VSS_r18 x_PM_LS_HLEN_X2%VSS_27 x_PM_LS_HLEN_X2%VSS_42 0.0731438
R_x_PM_LS_HLEN_X2%VSS_r19 x_PM_LS_HLEN_X2%VSS_27 VSS 0.972353
R_x_PM_LS_HLEN_X2%VSS_r20 x_PM_LS_HLEN_X2%VSS_26 x_PM_LS_HLEN_X2%VSS_43 0.0731438
R_x_PM_LS_HLEN_X2%VSS_r21 x_PM_LS_HLEN_X2%VSS_26 VSS 0.0782353
R_x_PM_LS_HLEN_X2%VSS_r22 x_PM_LS_HLEN_X2%VSS_36 N_VSS_M3_b 0.502143
R_x_PM_LS_HLEN_X2%VSS_r23 x_PM_LS_HLEN_X2%VSS_22 x_PM_LS_HLEN_X2%VSS_42 0.145286
R_x_PM_LS_HLEN_X2%VSS_r24 x_PM_LS_HLEN_X2%VSS_22 N_VSS_M3_b 0.502143
R_x_PM_LS_HLEN_X2%VSS_r25 x_PM_LS_HLEN_X2%VSS_18 VSS 18.1953
R_x_PM_LS_HLEN_X2%VSS_r26 x_PM_LS_HLEN_X2%VSS_16 x_PM_LS_HLEN_X2%VSS_42 0.0731438
R_x_PM_LS_HLEN_X2%VSS_r27 x_PM_LS_HLEN_X2%VSS_16 x_PM_LS_HLEN_X2%VSS_17 7.93529
R_x_PM_LS_HLEN_X2%VSS_r28 x_PM_LS_HLEN_X2%VSS_12 x_PM_LS_HLEN_X2%VSS_18 0.264221
R_x_PM_LS_HLEN_X2%VSS_r29 x_PM_LS_HLEN_X2%VSS_8 x_PM_LS_HLEN_X2%VSS_17 0.264221
R_x_PM_LS_HLEN_X2%VSS_r30 x_PM_LS_HLEN_X2%VSS_8 N_VSS_M3_b 0.5016
C_x_PM_LS_HLEN_X2%3_c0 x_PM_LS_HLEN_X2%3_30 VSS 0.0123231f
C_x_PM_LS_HLEN_X2%3_c1 x_PM_LS_HLEN_X2%3_26 VSS 0.0749698f
C_x_PM_LS_HLEN_X2%3_c2 x_PM_LS_HLEN_X2%3_22 VSS 0.0172326f
C_x_PM_LS_HLEN_X2%3_c3 x_PM_LS_HLEN_X2%3_21 VSS 0.0369174f
C_x_PM_LS_HLEN_X2%3_c4 N_3_M0_d VSS 0.0353654f
C_x_PM_LS_HLEN_X2%3_c5 x_PM_LS_HLEN_X2%3_16 VSS 0.0136045f
C_x_PM_LS_HLEN_X2%3_c6 x_PM_LS_HLEN_X2%3_15 VSS 0.0865791f
C_x_PM_LS_HLEN_X2%3_c7 N_3_M3_s VSS 0.0185031f
C_x_PM_LS_HLEN_X2%3_c8 N_3_M2_g VSS 0.0605609f
C_x_PM_LS_HLEN_X2%3_c9 N_3_M5_g VSS 0.0483776f
R_x_PM_LS_HLEN_X2%3_r10 x_PM_LS_HLEN_X2%3_28 x_PM_LS_HLEN_X2%3_30 4.42
R_x_PM_LS_HLEN_X2%3_r11 x_PM_LS_HLEN_X2%3_26 x_PM_LS_HLEN_X2%3_28 25.0012
R_x_PM_LS_HLEN_X2%3_r12 x_PM_LS_HLEN_X2%3_24 x_PM_LS_HLEN_X2%3_26 0.502143
R_x_PM_LS_HLEN_X2%3_r13 x_PM_LS_HLEN_X2%3_23 x_PM_LS_HLEN_X2%3_26 0.990714
R_x_PM_LS_HLEN_X2%3_r14 x_PM_LS_HLEN_X2%3_21 x_PM_LS_HLEN_X2%3_24 0.212317
R_x_PM_LS_HLEN_X2%3_r15 x_PM_LS_HLEN_X2%3_21 x_PM_LS_HLEN_X2%3_22 0.895714
R_x_PM_LS_HLEN_X2%3_r16 x_PM_LS_HLEN_X2%3_17 x_PM_LS_HLEN_X2%3_22 0.212317
R_x_PM_LS_HLEN_X2%3_r17 x_PM_LS_HLEN_X2%3_17 N_3_M0_d 1.235
R_x_PM_LS_HLEN_X2%3_r18 x_PM_LS_HLEN_X2%3_15 x_PM_LS_HLEN_X2%3_23 0.212317
R_x_PM_LS_HLEN_X2%3_r19 x_PM_LS_HLEN_X2%3_15 x_PM_LS_HLEN_X2%3_16 1.92714
R_x_PM_LS_HLEN_X2%3_r20 x_PM_LS_HLEN_X2%3_11 x_PM_LS_HLEN_X2%3_16 0.212317
R_x_PM_LS_HLEN_X2%3_r21 x_PM_LS_HLEN_X2%3_11 N_3_M3_s 0.149286
R_x_PM_LS_HLEN_X2%3_r22 x_PM_LS_HLEN_X2%3_5 x_PM_LS_HLEN_X2%3_30 1.95
R_x_PM_LS_HLEN_X2%3_r23 x_PM_LS_HLEN_X2%3_5 N_3_M2_g 48.75
R_x_PM_LS_HLEN_X2%3_r24 x_PM_LS_HLEN_X2%3_1 x_PM_LS_HLEN_X2%3_30 1.95
R_x_PM_LS_HLEN_X2%3_r25 x_PM_LS_HLEN_X2%3_1 N_3_M5_g 36.27
C_x_PM_LS_HLEN_X2%A_c0 x_PM_LS_HLEN_X2%A_14 VSS 0.00734584f
C_x_PM_LS_HLEN_X2%A_c1 x_PM_LS_HLEN_X2%A_12 VSS 0.0554593f
C_x_PM_LS_HLEN_X2%A_c2 N_A_M0_g VSS 0.0585385f
C_x_PM_LS_HLEN_X2%A_c3 N_A_M3_g VSS 0.0445007f
R_x_PM_LS_HLEN_X2%A_r4 x_PM_LS_HLEN_X2%A_14 x_PM_LS_HLEN_X2%A_18 4.74714
R_x_PM_LS_HLEN_X2%A_r5 x_PM_LS_HLEN_X2%A_14 x_PM_LS_HLEN_X2%A_17 4.74714
R_x_PM_LS_HLEN_X2%A_r6 x_PM_LS_HLEN_X2%A_12 x_PM_LS_HLEN_X2%A_14 25.0012
R_x_PM_LS_HLEN_X2%A_r7 A x_PM_LS_HLEN_X2%A_12 0.156071
R_x_PM_LS_HLEN_X2%A_r8 x_PM_LS_HLEN_X2%A_18 N_A_M0_g 72.15
R_x_PM_LS_HLEN_X2%A_r9 x_PM_LS_HLEN_X2%A_17 N_A_M3_g 39
C_x_PM_LS_HLEN_X2%ISOLN_c0 x_PM_LS_HLEN_X2%ISOLN_14 VSS 0.0089801f
C_x_PM_LS_HLEN_X2%ISOLN_c1 x_PM_LS_HLEN_X2%ISOLN_12 VSS 0.0895959f
C_x_PM_LS_HLEN_X2%ISOLN_c2 N_ISOLN_M1_g VSS 0.0655355f
C_x_PM_LS_HLEN_X2%ISOLN_c3 N_ISOLN_M4_g VSS 0.0425689f
R_x_PM_LS_HLEN_X2%ISOLN_r4 x_PM_LS_HLEN_X2%ISOLN_14 x_PM_LS_HLEN_X2%ISOLN_18 4.7687
R_x_PM_LS_HLEN_X2%ISOLN_r5 x_PM_LS_HLEN_X2%ISOLN_14 x_PM_LS_HLEN_X2%ISOLN_17 4.7687
R_x_PM_LS_HLEN_X2%ISOLN_r6 x_PM_LS_HLEN_X2%ISOLN_12 x_PM_LS_HLEN_X2%ISOLN_14 25.0012
R_x_PM_LS_HLEN_X2%ISOLN_r7 ISOLN x_PM_LS_HLEN_X2%ISOLN_12 0.169643
R_x_PM_LS_HLEN_X2%ISOLN_r8 x_PM_LS_HLEN_X2%ISOLN_18 N_ISOLN_M1_g 72.93
R_x_PM_LS_HLEN_X2%ISOLN_r9 x_PM_LS_HLEN_X2%ISOLN_17 N_ISOLN_M4_g 38.22
C_x_PM_LS_HLEN_X2%Z_c0 N_Z_M5_d VSS 0.134219f
R_x_PM_LS_HLEN_X2%Z_r1 Z N_Z_M2_d 1.10833
R_x_PM_LS_HLEN_X2%Z_r2 N_Z_M5_d Z 1.045
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_HLEN_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_HLEN_X4 VDDL VSS A ISOLN Z
*.PININFO VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M4 N_3_M0_d N_A_M0_g N_VDDL_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=3.9e-07
M_M5 N_VDDL_M1_d N_ISOLN_M1_g N_3_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=3.9e-07
M_M6 N_Z_M2_d N_3_M2_g N_VDDL_M1_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=4.15e-07
M_M7 N_VDDL_M3_d N_3_M3_g N_Z_M2_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=4.15e-07
M_M0 7 N_A_M4_g N_3_M4_s N_VSS_M4_b NMOS_VTL L=5e-08 W=3.4e-07
M_M1 N_VSS_M5_d N_ISOLN_M5_g 7 N_VSS_M4_b NMOS_VTL L=5e-08 W=3.4e-07
M_M2 N_Z_M6_d N_3_M6_g N_VSS_M5_d N_VSS_M4_b NMOS_VTL L=5e-08 W=3.05e-07
M_M3 N_VSS_M7_d N_3_M7_g N_Z_M6_d N_VSS_M4_b NMOS_VTL L=5e-08 W=3.05e-07
C_x_PM_LS_HLEN_X4%VDDL_c0 x_PM_LS_HLEN_X4%VDDL_54 VSS 0.00304048f
C_x_PM_LS_HLEN_X4%VDDL_c1 VDDL VSS 0.254713f
C_x_PM_LS_HLEN_X4%VDDL_c2 x_PM_LS_HLEN_X4%VDDL_48 VSS 0.0111802f
C_x_PM_LS_HLEN_X4%VDDL_c3 N_VDDL_M3_d VSS 0.0301458f
C_x_PM_LS_HLEN_X4%VDDL_c4 x_PM_LS_HLEN_X4%VDDL_38 VSS 0.019185f
C_x_PM_LS_HLEN_X4%VDDL_c5 N_VDDL_M1_d VSS 0.0588115f
C_x_PM_LS_HLEN_X4%VDDL_c6 x_PM_LS_HLEN_X4%VDDL_33 VSS 0.0114118f
C_x_PM_LS_HLEN_X4%VDDL_c7 x_PM_LS_HLEN_X4%VDDL_32 VSS 0.0186978f
C_x_PM_LS_HLEN_X4%VDDL_c8 N_VDDL_M0_s VSS 0.0351693f
C_x_PM_LS_HLEN_X4%VDDL_c9 x_PM_LS_HLEN_X4%VDDL_23 VSS 0.0120441f
C_x_PM_LS_HLEN_X4%VDDL_c10 x_PM_LS_HLEN_X4%VDDL_22 VSS 0.240864f
C_x_PM_LS_HLEN_X4%VDDL_c11 VDDL VSS 0.601844f
C_x_PM_LS_HLEN_X4%VDDL_c12 N_VDDL_M0_b VSS 0.0362568f
R_x_PM_LS_HLEN_X4%VDDL_r13 x_PM_LS_HLEN_X4%VDDL_55 x_PM_LS_HLEN_X4%VDDL_56 0.413529
R_x_PM_LS_HLEN_X4%VDDL_r14 x_PM_LS_HLEN_X4%VDDL_52 x_PM_LS_HLEN_X4%VDDL_53 0.424706
R_x_PM_LS_HLEN_X4%VDDL_r15 x_PM_LS_HLEN_X4%VDDL_48 x_PM_LS_HLEN_X4%VDDL_56 0.0782353
R_x_PM_LS_HLEN_X4%VDDL_r16 x_PM_LS_HLEN_X4%VDDL_48 VDDL 8.03588
R_x_PM_LS_HLEN_X4%VDDL_r17 x_PM_LS_HLEN_X4%VDDL_44 x_PM_LS_HLEN_X4%VDDL_56 0.095
R_x_PM_LS_HLEN_X4%VDDL_r18 x_PM_LS_HLEN_X4%VDDL_40 x_PM_LS_HLEN_X4%VDDL_55 0.095
R_x_PM_LS_HLEN_X4%VDDL_r19 x_PM_LS_HLEN_X4%VDDL_40 N_VDDL_M3_d 1.58786
R_x_PM_LS_HLEN_X4%VDDL_r20 x_PM_LS_HLEN_X4%VDDL_39 x_PM_LS_HLEN_X4%VDDL_54 0.0731438
R_x_PM_LS_HLEN_X4%VDDL_r21 x_PM_LS_HLEN_X4%VDDL_38 x_PM_LS_HLEN_X4%VDDL_55 0.0782353
R_x_PM_LS_HLEN_X4%VDDL_r22 x_PM_LS_HLEN_X4%VDDL_38 x_PM_LS_HLEN_X4%VDDL_39 0.692941
R_x_PM_LS_HLEN_X4%VDDL_r23 x_PM_LS_HLEN_X4%VDDL_34 x_PM_LS_HLEN_X4%VDDL_54 0.145286
R_x_PM_LS_HLEN_X4%VDDL_r24 x_PM_LS_HLEN_X4%VDDL_34 N_VDDL_M1_d 1.72357
R_x_PM_LS_HLEN_X4%VDDL_r25 x_PM_LS_HLEN_X4%VDDL_33 x_PM_LS_HLEN_X4%VDDL_53 0.0782353
R_x_PM_LS_HLEN_X4%VDDL_r26 x_PM_LS_HLEN_X4%VDDL_32 x_PM_LS_HLEN_X4%VDDL_54 0.0731438
R_x_PM_LS_HLEN_X4%VDDL_r27 x_PM_LS_HLEN_X4%VDDL_32 x_PM_LS_HLEN_X4%VDDL_33 0.681765
R_x_PM_LS_HLEN_X4%VDDL_r28 x_PM_LS_HLEN_X4%VDDL_28 x_PM_LS_HLEN_X4%VDDL_53 0.095
R_x_PM_LS_HLEN_X4%VDDL_r29 x_PM_LS_HLEN_X4%VDDL_28 N_VDDL_M0_s 1.72357
R_x_PM_LS_HLEN_X4%VDDL_r30 x_PM_LS_HLEN_X4%VDDL_24 x_PM_LS_HLEN_X4%VDDL_52 0.095
R_x_PM_LS_HLEN_X4%VDDL_r31 x_PM_LS_HLEN_X4%VDDL_22 x_PM_LS_HLEN_X4%VDDL_52 0.0782353
R_x_PM_LS_HLEN_X4%VDDL_r32 x_PM_LS_HLEN_X4%VDDL_22 x_PM_LS_HLEN_X4%VDDL_23 7.93529
R_x_PM_LS_HLEN_X4%VDDL_r33 x_PM_LS_HLEN_X4%VDDL_14 x_PM_LS_HLEN_X4%VDDL_23 0.264221
R_x_PM_LS_HLEN_X4%VDDL_r34 x_PM_LS_HLEN_X4%VDDL_44 N_VDDL_M0_b 0.827857
R_x_PM_LS_HLEN_X4%VDDL_r35 x_PM_LS_HLEN_X4%VDDL_24 N_VDDL_M0_b 0.827857
R_x_PM_LS_HLEN_X4%VDDL_r36 x_PM_LS_HLEN_X4%VDDL_14 N_VDDL_M0_b 0.827857
C_x_PM_LS_HLEN_X4%VSS_c0 x_PM_LS_HLEN_X4%VSS_50 VSS 0.265628f
C_x_PM_LS_HLEN_X4%VSS_c1 x_PM_LS_HLEN_X4%VSS_48 VSS 0.00268952f
C_x_PM_LS_HLEN_X4%VSS_c2 x_PM_LS_HLEN_X4%VSS_47 VSS 0.00292673f
C_x_PM_LS_HLEN_X4%VSS_c3 N_VSS_M7_d VSS 0.0248178f
C_x_PM_LS_HLEN_X4%VSS_c4 x_PM_LS_HLEN_X4%VSS_35 VSS 0.0395753f
C_x_PM_LS_HLEN_X4%VSS_c5 VSS VSS 0.020813f
C_x_PM_LS_HLEN_X4%VSS_c6 x_PM_LS_HLEN_X4%VSS_27 VSS 0.0489705f
C_x_PM_LS_HLEN_X4%VSS_c7 N_VSS_M4_b VSS 0.0309261f
C_x_PM_LS_HLEN_X4%VSS_c8 VSS VSS 0.57532f
C_x_PM_LS_HLEN_X4%VSS_c9 x_PM_LS_HLEN_X4%VSS_19 VSS 0.011992f
C_x_PM_LS_HLEN_X4%VSS_c10 x_PM_LS_HLEN_X4%VSS_18 VSS 0.0120195f
C_x_PM_LS_HLEN_X4%VSS_c11 x_PM_LS_HLEN_X4%VSS_17 VSS 0.240864f
C_x_PM_LS_HLEN_X4%VSS_c12 x_PM_LS_HLEN_X4%VSS_13 VSS 0.0110902f
R_x_PM_LS_HLEN_X4%VSS_r13 x_PM_LS_HLEN_X4%VSS_49 x_PM_LS_HLEN_X4%VSS_50 0.413529
R_x_PM_LS_HLEN_X4%VSS_r14 x_PM_LS_HLEN_X4%VSS_41 x_PM_LS_HLEN_X4%VSS_50 0.095
R_x_PM_LS_HLEN_X4%VSS_r15 x_PM_LS_HLEN_X4%VSS_37 x_PM_LS_HLEN_X4%VSS_49 0.095
R_x_PM_LS_HLEN_X4%VSS_r16 x_PM_LS_HLEN_X4%VSS_37 N_VSS_M7_d 1.01786
R_x_PM_LS_HLEN_X4%VSS_r17 x_PM_LS_HLEN_X4%VSS_36 x_PM_LS_HLEN_X4%VSS_48 0.0731438
R_x_PM_LS_HLEN_X4%VSS_r18 x_PM_LS_HLEN_X4%VSS_35 x_PM_LS_HLEN_X4%VSS_49 0.0782353
R_x_PM_LS_HLEN_X4%VSS_r19 x_PM_LS_HLEN_X4%VSS_35 x_PM_LS_HLEN_X4%VSS_36 0.692941
R_x_PM_LS_HLEN_X4%VSS_r20 VSS N_VSS_M5_d 0.0271429
R_x_PM_LS_HLEN_X4%VSS_r21 x_PM_LS_HLEN_X4%VSS_29 x_PM_LS_HLEN_X4%VSS_48 0.145286
R_x_PM_LS_HLEN_X4%VSS_r22 x_PM_LS_HLEN_X4%VSS_29 VSS 0.230714
R_x_PM_LS_HLEN_X4%VSS_r23 x_PM_LS_HLEN_X4%VSS_28 x_PM_LS_HLEN_X4%VSS_47 0.0731438
R_x_PM_LS_HLEN_X4%VSS_r24 x_PM_LS_HLEN_X4%VSS_27 x_PM_LS_HLEN_X4%VSS_48 0.0731438
R_x_PM_LS_HLEN_X4%VSS_r25 x_PM_LS_HLEN_X4%VSS_27 x_PM_LS_HLEN_X4%VSS_28 1.10647
R_x_PM_LS_HLEN_X4%VSS_r26 x_PM_LS_HLEN_X4%VSS_41 N_VSS_M4_b 0.502143
R_x_PM_LS_HLEN_X4%VSS_r27 x_PM_LS_HLEN_X4%VSS_23 x_PM_LS_HLEN_X4%VSS_47 0.145286
R_x_PM_LS_HLEN_X4%VSS_r28 x_PM_LS_HLEN_X4%VSS_23 N_VSS_M4_b 0.502143
R_x_PM_LS_HLEN_X4%VSS_r29 x_PM_LS_HLEN_X4%VSS_19 VSS 18.62
R_x_PM_LS_HLEN_X4%VSS_r30 x_PM_LS_HLEN_X4%VSS_17 x_PM_LS_HLEN_X4%VSS_47 0.0731438
R_x_PM_LS_HLEN_X4%VSS_r31 x_PM_LS_HLEN_X4%VSS_17 x_PM_LS_HLEN_X4%VSS_18 7.93529
R_x_PM_LS_HLEN_X4%VSS_r32 x_PM_LS_HLEN_X4%VSS_13 x_PM_LS_HLEN_X4%VSS_19 0.264221
R_x_PM_LS_HLEN_X4%VSS_r33 x_PM_LS_HLEN_X4%VSS_9 x_PM_LS_HLEN_X4%VSS_18 0.264221
R_x_PM_LS_HLEN_X4%VSS_r34 x_PM_LS_HLEN_X4%VSS_9 N_VSS_M4_b 0.5016
C_x_PM_LS_HLEN_X4%3_c0 x_PM_LS_HLEN_X4%3_35 VSS 0.0822856f
C_x_PM_LS_HLEN_X4%3_c1 x_PM_LS_HLEN_X4%3_31 VSS 0.0208599f
C_x_PM_LS_HLEN_X4%3_c2 x_PM_LS_HLEN_X4%3_30 VSS 0.0487686f
C_x_PM_LS_HLEN_X4%3_c3 N_3_M0_d VSS 0.0339546f
C_x_PM_LS_HLEN_X4%3_c4 x_PM_LS_HLEN_X4%3_22 VSS 0.107892f
C_x_PM_LS_HLEN_X4%3_c5 x_PM_LS_HLEN_X4%3_19 VSS 0.00330952f
C_x_PM_LS_HLEN_X4%3_c6 N_3_M3_g VSS 0.0413496f
C_x_PM_LS_HLEN_X4%3_c7 N_3_M7_g VSS 0.0390928f
C_x_PM_LS_HLEN_X4%3_c8 x_PM_LS_HLEN_X4%3_10 VSS 0.00819931f
C_x_PM_LS_HLEN_X4%3_c9 x_PM_LS_HLEN_X4%3_9 VSS 0.0122074f
C_x_PM_LS_HLEN_X4%3_c10 N_3_M2_g VSS 0.0374343f
C_x_PM_LS_HLEN_X4%3_c11 N_3_M6_g VSS 0.0334073f
R_x_PM_LS_HLEN_X4%3_r12 x_PM_LS_HLEN_X4%3_37 x_PM_LS_HLEN_X4%3_39 4.94
R_x_PM_LS_HLEN_X4%3_r13 x_PM_LS_HLEN_X4%3_35 x_PM_LS_HLEN_X4%3_37 25.0012
R_x_PM_LS_HLEN_X4%3_r14 x_PM_LS_HLEN_X4%3_33 x_PM_LS_HLEN_X4%3_35 0.610714
R_x_PM_LS_HLEN_X4%3_r15 x_PM_LS_HLEN_X4%3_32 x_PM_LS_HLEN_X4%3_35 1.01786
R_x_PM_LS_HLEN_X4%3_r16 x_PM_LS_HLEN_X4%3_30 x_PM_LS_HLEN_X4%3_33 0.212317
R_x_PM_LS_HLEN_X4%3_r17 x_PM_LS_HLEN_X4%3_30 x_PM_LS_HLEN_X4%3_31 0.868571
R_x_PM_LS_HLEN_X4%3_r18 x_PM_LS_HLEN_X4%3_26 x_PM_LS_HLEN_X4%3_31 0.212317
R_x_PM_LS_HLEN_X4%3_r19 x_PM_LS_HLEN_X4%3_26 N_3_M0_d 0.746429
R_x_PM_LS_HLEN_X4%3_r20 x_PM_LS_HLEN_X4%3_22 x_PM_LS_HLEN_X4%3_32 0.212317
R_x_PM_LS_HLEN_X4%3_r21 x_PM_LS_HLEN_X4%3_22 N_3_M4_s 2.10357
R_x_PM_LS_HLEN_X4%3_r22 x_PM_LS_HLEN_X4%3_15 x_PM_LS_HLEN_X4%3_19 4.56151
R_x_PM_LS_HLEN_X4%3_r23 x_PM_LS_HLEN_X4%3_15 N_3_M3_g 42.51
R_x_PM_LS_HLEN_X4%3_r24 x_PM_LS_HLEN_X4%3_11 x_PM_LS_HLEN_X4%3_19 4.56151
R_x_PM_LS_HLEN_X4%3_r25 x_PM_LS_HLEN_X4%3_11 N_3_M7_g 40.17
R_x_PM_LS_HLEN_X4%3_r26 x_PM_LS_HLEN_X4%3_10 x_PM_LS_HLEN_X4%3_39 2.6
R_x_PM_LS_HLEN_X4%3_r27 x_PM_LS_HLEN_X4%3_9 x_PM_LS_HLEN_X4%3_19 0.043368
R_x_PM_LS_HLEN_X4%3_r28 x_PM_LS_HLEN_X4%3_9 x_PM_LS_HLEN_X4%3_10 14.56
R_x_PM_LS_HLEN_X4%3_r29 x_PM_LS_HLEN_X4%3_5 x_PM_LS_HLEN_X4%3_39 1.95
R_x_PM_LS_HLEN_X4%3_r30 x_PM_LS_HLEN_X4%3_5 N_3_M2_g 42.51
R_x_PM_LS_HLEN_X4%3_r31 x_PM_LS_HLEN_X4%3_1 x_PM_LS_HLEN_X4%3_39 1.95
R_x_PM_LS_HLEN_X4%3_r32 x_PM_LS_HLEN_X4%3_1 N_3_M6_g 40.17
C_x_PM_LS_HLEN_X4%A_c0 x_PM_LS_HLEN_X4%A_18 VSS 0.00948225f
C_x_PM_LS_HLEN_X4%A_c1 x_PM_LS_HLEN_X4%A_12 VSS 0.0654632f
C_x_PM_LS_HLEN_X4%A_c2 N_A_M0_g VSS 0.0550724f
C_x_PM_LS_HLEN_X4%A_c3 N_A_M4_g VSS 0.0467392f
R_x_PM_LS_HLEN_X4%A_r4 x_PM_LS_HLEN_X4%A_14 x_PM_LS_HLEN_X4%A_18 4.42
R_x_PM_LS_HLEN_X4%A_r5 x_PM_LS_HLEN_X4%A_12 x_PM_LS_HLEN_X4%A_14 25.0012
R_x_PM_LS_HLEN_X4%A_r6 A x_PM_LS_HLEN_X4%A_12 0.128529
R_x_PM_LS_HLEN_X4%A_r7 x_PM_LS_HLEN_X4%A_5 x_PM_LS_HLEN_X4%A_18 1.95
R_x_PM_LS_HLEN_X4%A_r8 x_PM_LS_HLEN_X4%A_5 N_A_M0_g 43.68
R_x_PM_LS_HLEN_X4%A_r9 x_PM_LS_HLEN_X4%A_1 x_PM_LS_HLEN_X4%A_18 1.95
R_x_PM_LS_HLEN_X4%A_r10 x_PM_LS_HLEN_X4%A_1 N_A_M4_g 34.32
C_x_PM_LS_HLEN_X4%ISOLN_c0 x_PM_LS_HLEN_X4%ISOLN_14 VSS 0.00934368f
C_x_PM_LS_HLEN_X4%ISOLN_c1 x_PM_LS_HLEN_X4%ISOLN_12 VSS 0.116421f
C_x_PM_LS_HLEN_X4%ISOLN_c2 N_ISOLN_M1_g VSS 0.0565552f
C_x_PM_LS_HLEN_X4%ISOLN_c3 N_ISOLN_M5_g VSS 0.0481641f
R_x_PM_LS_HLEN_X4%ISOLN_r4 x_PM_LS_HLEN_X4%ISOLN_14 x_PM_LS_HLEN_X4%ISOLN_18 4.7687
R_x_PM_LS_HLEN_X4%ISOLN_r5 x_PM_LS_HLEN_X4%ISOLN_14 x_PM_LS_HLEN_X4%ISOLN_17 4.7687
R_x_PM_LS_HLEN_X4%ISOLN_r6 x_PM_LS_HLEN_X4%ISOLN_12 x_PM_LS_HLEN_X4%ISOLN_14 25.0012
R_x_PM_LS_HLEN_X4%ISOLN_r7 ISOLN x_PM_LS_HLEN_X4%ISOLN_12 0.195588
R_x_PM_LS_HLEN_X4%ISOLN_r8 x_PM_LS_HLEN_X4%ISOLN_18 N_ISOLN_M1_g 43.68
R_x_PM_LS_HLEN_X4%ISOLN_r9 x_PM_LS_HLEN_X4%ISOLN_17 N_ISOLN_M5_g 34.32
C_x_PM_LS_HLEN_X4%Z_c0 N_Z_M6_d VSS 0.166864f
R_x_PM_LS_HLEN_X4%Z_r1 Z N_Z_M2_d 1.96786
R_x_PM_LS_HLEN_X4%Z_r2 N_Z_M6_d Z 0.719286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_HL_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_HL_X1 VDDL VSS A Z
*.PININFO VDDL:P VSS:G A:I Z:O
*.EQN Z=A
M_M2 N_VDDL_M0_d N_A_M0_g N_3_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M3 N_Z_M1_d N_3_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s N_VSS_M2_b NMOS_VTL L=5e-08 W=1.55e-07
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d N_VSS_M2_b NMOS_VTL L=5e-08 W=1.55e-07
C_x_PM_LS_HL_X1%VDDL_c0 x_PM_LS_HL_X1%VDDL_44 VSS 0.00295132f
C_x_PM_LS_HL_X1%VDDL_c1 x_PM_LS_HL_X1%VDDL_43 VSS 0.00304277f
C_x_PM_LS_HL_X1%VDDL_c2 x_PM_LS_HL_X1%VDDL_42 VSS 0.00295132f
C_x_PM_LS_HL_X1%VDDL_c3 VDDL VSS 0.254713f
C_x_PM_LS_HL_X1%VDDL_c4 x_PM_LS_HL_X1%VDDL_32 VSS 0.0200125f
C_x_PM_LS_HL_X1%VDDL_c5 N_VDDL_M0_d VSS 0.0501233f
C_x_PM_LS_HL_X1%VDDL_c6 x_PM_LS_HL_X1%VDDL_26 VSS 0.0164049f
C_x_PM_LS_HL_X1%VDDL_c7 x_PM_LS_HL_X1%VDDL_21 VSS 0.0120441f
C_x_PM_LS_HL_X1%VDDL_c8 x_PM_LS_HL_X1%VDDL_20 VSS 0.240864f
C_x_PM_LS_HL_X1%VDDL_c9 VDDL VSS 0.576137f
C_x_PM_LS_HL_X1%VDDL_c10 N_VDDL_M0_b VSS 0.0380838f
R_x_PM_LS_HL_X1%VDDL_r11 x_PM_LS_HL_X1%VDDL_38 x_PM_LS_HL_X1%VDDL_44 0.0731438
R_x_PM_LS_HL_X1%VDDL_r12 x_PM_LS_HL_X1%VDDL_38 VDDL 8.03588
R_x_PM_LS_HL_X1%VDDL_r13 x_PM_LS_HL_X1%VDDL_34 x_PM_LS_HL_X1%VDDL_44 0.145286
R_x_PM_LS_HL_X1%VDDL_r14 x_PM_LS_HL_X1%VDDL_33 x_PM_LS_HL_X1%VDDL_43 0.0731438
R_x_PM_LS_HL_X1%VDDL_r15 x_PM_LS_HL_X1%VDDL_32 x_PM_LS_HL_X1%VDDL_44 0.0731438
R_x_PM_LS_HL_X1%VDDL_r16 x_PM_LS_HL_X1%VDDL_32 x_PM_LS_HL_X1%VDDL_33 0.737647
R_x_PM_LS_HL_X1%VDDL_r17 x_PM_LS_HL_X1%VDDL_28 x_PM_LS_HL_X1%VDDL_43 0.145286
R_x_PM_LS_HL_X1%VDDL_r18 x_PM_LS_HL_X1%VDDL_28 N_VDDL_M0_d 2.53786
R_x_PM_LS_HL_X1%VDDL_r19 x_PM_LS_HL_X1%VDDL_27 x_PM_LS_HL_X1%VDDL_42 0.0731438
R_x_PM_LS_HL_X1%VDDL_r20 x_PM_LS_HL_X1%VDDL_26 x_PM_LS_HL_X1%VDDL_43 0.0731438
R_x_PM_LS_HL_X1%VDDL_r21 x_PM_LS_HL_X1%VDDL_26 x_PM_LS_HL_X1%VDDL_27 0.625882
R_x_PM_LS_HL_X1%VDDL_r22 x_PM_LS_HL_X1%VDDL_22 x_PM_LS_HL_X1%VDDL_42 0.145286
R_x_PM_LS_HL_X1%VDDL_r23 x_PM_LS_HL_X1%VDDL_20 x_PM_LS_HL_X1%VDDL_42 0.0731438
R_x_PM_LS_HL_X1%VDDL_r24 x_PM_LS_HL_X1%VDDL_20 x_PM_LS_HL_X1%VDDL_21 7.93529
R_x_PM_LS_HL_X1%VDDL_r25 x_PM_LS_HL_X1%VDDL_12 x_PM_LS_HL_X1%VDDL_21 0.264221
R_x_PM_LS_HL_X1%VDDL_r26 x_PM_LS_HL_X1%VDDL_34 N_VDDL_M0_b 0.827857
R_x_PM_LS_HL_X1%VDDL_r27 x_PM_LS_HL_X1%VDDL_22 N_VDDL_M0_b 0.827857
R_x_PM_LS_HL_X1%VDDL_r28 x_PM_LS_HL_X1%VDDL_12 N_VDDL_M0_b 0.827857
C_x_PM_LS_HL_X1%VSS_c0 x_PM_LS_HL_X1%VSS_43 VSS 0.25764f
C_x_PM_LS_HL_X1%VSS_c1 VSS VSS 0.00280728f
C_x_PM_LS_HL_X1%VSS_c2 x_PM_LS_HL_X1%VSS_40 VSS 0.00292673f
C_x_PM_LS_HL_X1%VSS_c3 N_VSS_M2_b VSS 0.0424599f
C_x_PM_LS_HL_X1%VSS_c4 x_PM_LS_HL_X1%VSS_32 VSS 0.0323966f
C_x_PM_LS_HL_X1%VSS_c5 N_VSS_M2_d VSS 0.029654f
C_x_PM_LS_HL_X1%VSS_c6 x_PM_LS_HL_X1%VSS_26 VSS 0.0276733f
C_x_PM_LS_HL_X1%VSS_c7 VSS VSS 0.549612f
C_x_PM_LS_HL_X1%VSS_c8 x_PM_LS_HL_X1%VSS_18 VSS 0.011992f
C_x_PM_LS_HL_X1%VSS_c9 x_PM_LS_HL_X1%VSS_17 VSS 0.0120195f
C_x_PM_LS_HL_X1%VSS_c10 x_PM_LS_HL_X1%VSS_16 VSS 0.240864f
C_x_PM_LS_HL_X1%VSS_c11 x_PM_LS_HL_X1%VSS_12 VSS 0.0110902f
R_x_PM_LS_HL_X1%VSS_r12 x_PM_LS_HL_X1%VSS_34 x_PM_LS_HL_X1%VSS_43 0.145286
R_x_PM_LS_HL_X1%VSS_r13 x_PM_LS_HL_X1%VSS_34 N_VSS_M2_b 0.502143
R_x_PM_LS_HL_X1%VSS_r14 x_PM_LS_HL_X1%VSS_33 VSS 0.0731438
R_x_PM_LS_HL_X1%VSS_r15 x_PM_LS_HL_X1%VSS_32 x_PM_LS_HL_X1%VSS_43 0.0731438
R_x_PM_LS_HL_X1%VSS_r16 x_PM_LS_HL_X1%VSS_32 x_PM_LS_HL_X1%VSS_33 0.737647
R_x_PM_LS_HL_X1%VSS_r17 x_PM_LS_HL_X1%VSS_28 VSS 0.145286
R_x_PM_LS_HL_X1%VSS_r18 x_PM_LS_HL_X1%VSS_28 N_VSS_M2_d 0.366429
R_x_PM_LS_HL_X1%VSS_r19 x_PM_LS_HL_X1%VSS_27 x_PM_LS_HL_X1%VSS_40 0.0731438
R_x_PM_LS_HL_X1%VSS_r20 x_PM_LS_HL_X1%VSS_26 VSS 0.0731438
R_x_PM_LS_HL_X1%VSS_r21 x_PM_LS_HL_X1%VSS_26 x_PM_LS_HL_X1%VSS_27 0.625882
R_x_PM_LS_HL_X1%VSS_r22 x_PM_LS_HL_X1%VSS_22 x_PM_LS_HL_X1%VSS_40 0.145286
R_x_PM_LS_HL_X1%VSS_r23 x_PM_LS_HL_X1%VSS_22 N_VSS_M2_b 0.502143
R_x_PM_LS_HL_X1%VSS_r24 x_PM_LS_HL_X1%VSS_18 VSS 17.7706
R_x_PM_LS_HL_X1%VSS_r25 x_PM_LS_HL_X1%VSS_16 x_PM_LS_HL_X1%VSS_40 0.0731438
R_x_PM_LS_HL_X1%VSS_r26 x_PM_LS_HL_X1%VSS_16 x_PM_LS_HL_X1%VSS_17 7.93529
R_x_PM_LS_HL_X1%VSS_r27 x_PM_LS_HL_X1%VSS_12 x_PM_LS_HL_X1%VSS_18 0.264221
R_x_PM_LS_HL_X1%VSS_r28 x_PM_LS_HL_X1%VSS_8 x_PM_LS_HL_X1%VSS_17 0.264221
R_x_PM_LS_HL_X1%VSS_r29 x_PM_LS_HL_X1%VSS_8 N_VSS_M2_b 0.5016
C_x_PM_LS_HL_X1%3_c0 x_PM_LS_HL_X1%3_31 VSS 0.0124513f
C_x_PM_LS_HL_X1%3_c1 x_PM_LS_HL_X1%3_24 VSS 0.0222663f
C_x_PM_LS_HL_X1%3_c2 x_PM_LS_HL_X1%3_22 VSS 0.0739719f
C_x_PM_LS_HL_X1%3_c3 x_PM_LS_HL_X1%3_17 VSS 0.0452861f
C_x_PM_LS_HL_X1%3_c4 x_PM_LS_HL_X1%3_16 VSS 0.0136229f
C_x_PM_LS_HL_X1%3_c5 x_PM_LS_HL_X1%3_15 VSS 0.0499323f
C_x_PM_LS_HL_X1%3_c6 N_3_M2_s VSS 0.0282405f
C_x_PM_LS_HL_X1%3_c7 N_3_M1_g VSS 0.0471053f
C_x_PM_LS_HL_X1%3_c8 N_3_M3_g VSS 0.0406559f
R_x_PM_LS_HL_X1%3_r9 x_PM_LS_HL_X1%3_29 x_PM_LS_HL_X1%3_31 4.42
R_x_PM_LS_HL_X1%3_r10 x_PM_LS_HL_X1%3_24 N_3_M0_s 0.312143
R_x_PM_LS_HL_X1%3_r11 x_PM_LS_HL_X1%3_22 x_PM_LS_HL_X1%3_29 25.0012
R_x_PM_LS_HL_X1%3_r12 x_PM_LS_HL_X1%3_20 x_PM_LS_HL_X1%3_22 0.882143
R_x_PM_LS_HL_X1%3_r13 x_PM_LS_HL_X1%3_19 x_PM_LS_HL_X1%3_22 0.583571
R_x_PM_LS_HL_X1%3_r14 x_PM_LS_HL_X1%3_18 x_PM_LS_HL_X1%3_24 0.095
R_x_PM_LS_HL_X1%3_r15 x_PM_LS_HL_X1%3_17 x_PM_LS_HL_X1%3_20 0.212317
R_x_PM_LS_HL_X1%3_r16 x_PM_LS_HL_X1%3_17 x_PM_LS_HL_X1%3_18 0.895714
R_x_PM_LS_HL_X1%3_r17 x_PM_LS_HL_X1%3_15 x_PM_LS_HL_X1%3_19 0.212317
R_x_PM_LS_HL_X1%3_r18 x_PM_LS_HL_X1%3_15 x_PM_LS_HL_X1%3_16 0.895714
R_x_PM_LS_HL_X1%3_r19 x_PM_LS_HL_X1%3_11 x_PM_LS_HL_X1%3_16 0.212317
R_x_PM_LS_HL_X1%3_r20 x_PM_LS_HL_X1%3_11 N_3_M2_s 0.285
R_x_PM_LS_HL_X1%3_r21 x_PM_LS_HL_X1%3_5 x_PM_LS_HL_X1%3_31 1.95
R_x_PM_LS_HL_X1%3_r22 x_PM_LS_HL_X1%3_5 N_3_M1_g 44.07
R_x_PM_LS_HL_X1%3_r23 x_PM_LS_HL_X1%3_1 x_PM_LS_HL_X1%3_31 1.95
R_x_PM_LS_HL_X1%3_r24 x_PM_LS_HL_X1%3_1 N_3_M3_g 36.27
C_x_PM_LS_HL_X1%A_c0 x_PM_LS_HL_X1%A_14 VSS 0.00761622f
C_x_PM_LS_HL_X1%A_c1 x_PM_LS_HL_X1%A_12 VSS 0.0686696f
C_x_PM_LS_HL_X1%A_c2 N_A_M0_g VSS 0.0431189f
C_x_PM_LS_HL_X1%A_c3 N_A_M2_g VSS 0.0444676f
R_x_PM_LS_HL_X1%A_r4 x_PM_LS_HL_X1%A_14 x_PM_LS_HL_X1%A_18 4.7687
R_x_PM_LS_HL_X1%A_r5 x_PM_LS_HL_X1%A_14 x_PM_LS_HL_X1%A_17 4.7687
R_x_PM_LS_HL_X1%A_r6 x_PM_LS_HL_X1%A_12 x_PM_LS_HL_X1%A_14 25.0012
R_x_PM_LS_HL_X1%A_r7 A x_PM_LS_HL_X1%A_12 0.169643
R_x_PM_LS_HL_X1%A_r8 x_PM_LS_HL_X1%A_18 N_A_M0_g 40.17
R_x_PM_LS_HL_X1%A_r9 x_PM_LS_HL_X1%A_17 N_A_M2_g 40.17
C_x_PM_LS_HL_X1%Z_c0 N_Z_M3_d VSS 0.131752f
R_x_PM_LS_HL_X1%Z_r1 Z N_Z_M1_d 1.25611
R_x_PM_LS_HL_X1%Z_r2 N_Z_M3_d Z 1.08722
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_HL_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_HL_X2 VDDL VSS A Z
*.PININFO VDDL:P VSS:G A:I Z:O
*.EQN Z=A
M_M2 N_VDDL_M0_d N_A_M0_g N_3_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.05e-07
M_M3 N_Z_M1_d N_3_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=4.15e-07
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s N_VSS_M2_b NMOS_VTL L=5e-08 W=1.55e-07
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d N_VSS_M2_b NMOS_VTL L=5e-08 W=3.05e-07
C_x_PM_LS_HL_X2%VDDL_c0 x_PM_LS_HL_X2%VDDL_44 VSS 0.00295132f
C_x_PM_LS_HL_X2%VDDL_c1 x_PM_LS_HL_X2%VDDL_43 VSS 0.00298731f
C_x_PM_LS_HL_X2%VDDL_c2 x_PM_LS_HL_X2%VDDL_42 VSS 0.00295132f
C_x_PM_LS_HL_X2%VDDL_c3 VDDL VSS 0.254713f
C_x_PM_LS_HL_X2%VDDL_c4 x_PM_LS_HL_X2%VDDL_32 VSS 0.0205979f
C_x_PM_LS_HL_X2%VDDL_c5 N_VDDL_M0_d VSS 0.0272044f
C_x_PM_LS_HL_X2%VDDL_c6 x_PM_LS_HL_X2%VDDL_26 VSS 0.0170895f
C_x_PM_LS_HL_X2%VDDL_c7 x_PM_LS_HL_X2%VDDL_21 VSS 0.0120441f
C_x_PM_LS_HL_X2%VDDL_c8 x_PM_LS_HL_X2%VDDL_20 VSS 0.240864f
C_x_PM_LS_HL_X2%VDDL_c9 VDDL VSS 0.576137f
C_x_PM_LS_HL_X2%VDDL_c10 N_VDDL_M0_b VSS 0.0385027f
R_x_PM_LS_HL_X2%VDDL_r11 x_PM_LS_HL_X2%VDDL_38 x_PM_LS_HL_X2%VDDL_44 0.0731438
R_x_PM_LS_HL_X2%VDDL_r12 x_PM_LS_HL_X2%VDDL_38 VDDL 8.03588
R_x_PM_LS_HL_X2%VDDL_r13 x_PM_LS_HL_X2%VDDL_34 x_PM_LS_HL_X2%VDDL_44 0.145286
R_x_PM_LS_HL_X2%VDDL_r14 x_PM_LS_HL_X2%VDDL_33 x_PM_LS_HL_X2%VDDL_43 0.0731438
R_x_PM_LS_HL_X2%VDDL_r15 x_PM_LS_HL_X2%VDDL_32 x_PM_LS_HL_X2%VDDL_44 0.0731438
R_x_PM_LS_HL_X2%VDDL_r16 x_PM_LS_HL_X2%VDDL_32 x_PM_LS_HL_X2%VDDL_33 0.737647
R_x_PM_LS_HL_X2%VDDL_r17 x_PM_LS_HL_X2%VDDL_28 x_PM_LS_HL_X2%VDDL_43 0.145286
R_x_PM_LS_HL_X2%VDDL_r18 x_PM_LS_HL_X2%VDDL_28 N_VDDL_M0_d 1.39786
R_x_PM_LS_HL_X2%VDDL_r19 x_PM_LS_HL_X2%VDDL_27 x_PM_LS_HL_X2%VDDL_42 0.0731438
R_x_PM_LS_HL_X2%VDDL_r20 x_PM_LS_HL_X2%VDDL_26 x_PM_LS_HL_X2%VDDL_43 0.0731438
R_x_PM_LS_HL_X2%VDDL_r21 x_PM_LS_HL_X2%VDDL_26 x_PM_LS_HL_X2%VDDL_27 0.625882
R_x_PM_LS_HL_X2%VDDL_r22 x_PM_LS_HL_X2%VDDL_22 x_PM_LS_HL_X2%VDDL_42 0.145286
R_x_PM_LS_HL_X2%VDDL_r23 x_PM_LS_HL_X2%VDDL_20 x_PM_LS_HL_X2%VDDL_42 0.0731438
R_x_PM_LS_HL_X2%VDDL_r24 x_PM_LS_HL_X2%VDDL_20 x_PM_LS_HL_X2%VDDL_21 7.93529
R_x_PM_LS_HL_X2%VDDL_r25 x_PM_LS_HL_X2%VDDL_12 x_PM_LS_HL_X2%VDDL_21 0.264221
R_x_PM_LS_HL_X2%VDDL_r26 x_PM_LS_HL_X2%VDDL_34 N_VDDL_M0_b 0.827857
R_x_PM_LS_HL_X2%VDDL_r27 x_PM_LS_HL_X2%VDDL_22 N_VDDL_M0_b 0.827857
R_x_PM_LS_HL_X2%VDDL_r28 x_PM_LS_HL_X2%VDDL_12 N_VDDL_M0_b 0.827857
C_x_PM_LS_HL_X2%VSS_c0 x_PM_LS_HL_X2%VSS_43 VSS 0.25764f
C_x_PM_LS_HL_X2%VSS_c1 VSS VSS 0.00280728f
C_x_PM_LS_HL_X2%VSS_c2 x_PM_LS_HL_X2%VSS_40 VSS 0.00292673f
C_x_PM_LS_HL_X2%VSS_c3 N_VSS_M2_b VSS 0.0418008f
C_x_PM_LS_HL_X2%VSS_c4 x_PM_LS_HL_X2%VSS_32 VSS 0.030447f
C_x_PM_LS_HL_X2%VSS_c5 N_VSS_M2_d VSS 0.029092f
C_x_PM_LS_HL_X2%VSS_c6 x_PM_LS_HL_X2%VSS_26 VSS 0.0276733f
C_x_PM_LS_HL_X2%VSS_c7 VSS VSS 0.549612f
C_x_PM_LS_HL_X2%VSS_c8 x_PM_LS_HL_X2%VSS_18 VSS 0.011992f
C_x_PM_LS_HL_X2%VSS_c9 x_PM_LS_HL_X2%VSS_17 VSS 0.0120195f
C_x_PM_LS_HL_X2%VSS_c10 x_PM_LS_HL_X2%VSS_16 VSS 0.240864f
C_x_PM_LS_HL_X2%VSS_c11 x_PM_LS_HL_X2%VSS_12 VSS 0.0110902f
R_x_PM_LS_HL_X2%VSS_r12 x_PM_LS_HL_X2%VSS_34 x_PM_LS_HL_X2%VSS_43 0.145286
R_x_PM_LS_HL_X2%VSS_r13 x_PM_LS_HL_X2%VSS_34 N_VSS_M2_b 0.502143
R_x_PM_LS_HL_X2%VSS_r14 x_PM_LS_HL_X2%VSS_33 VSS 0.0731438
R_x_PM_LS_HL_X2%VSS_r15 x_PM_LS_HL_X2%VSS_32 x_PM_LS_HL_X2%VSS_43 0.0731438
R_x_PM_LS_HL_X2%VSS_r16 x_PM_LS_HL_X2%VSS_32 x_PM_LS_HL_X2%VSS_33 0.737647
R_x_PM_LS_HL_X2%VSS_r17 x_PM_LS_HL_X2%VSS_28 VSS 0.145286
R_x_PM_LS_HL_X2%VSS_r18 x_PM_LS_HL_X2%VSS_28 N_VSS_M2_d 0.366429
R_x_PM_LS_HL_X2%VSS_r19 x_PM_LS_HL_X2%VSS_27 x_PM_LS_HL_X2%VSS_40 0.0731438
R_x_PM_LS_HL_X2%VSS_r20 x_PM_LS_HL_X2%VSS_26 VSS 0.0731438
R_x_PM_LS_HL_X2%VSS_r21 x_PM_LS_HL_X2%VSS_26 x_PM_LS_HL_X2%VSS_27 0.625882
R_x_PM_LS_HL_X2%VSS_r22 x_PM_LS_HL_X2%VSS_22 x_PM_LS_HL_X2%VSS_40 0.145286
R_x_PM_LS_HL_X2%VSS_r23 x_PM_LS_HL_X2%VSS_22 N_VSS_M2_b 0.502143
R_x_PM_LS_HL_X2%VSS_r24 x_PM_LS_HL_X2%VSS_18 VSS 17.7706
R_x_PM_LS_HL_X2%VSS_r25 x_PM_LS_HL_X2%VSS_16 x_PM_LS_HL_X2%VSS_40 0.0731438
R_x_PM_LS_HL_X2%VSS_r26 x_PM_LS_HL_X2%VSS_16 x_PM_LS_HL_X2%VSS_17 7.93529
R_x_PM_LS_HL_X2%VSS_r27 x_PM_LS_HL_X2%VSS_12 x_PM_LS_HL_X2%VSS_18 0.264221
R_x_PM_LS_HL_X2%VSS_r28 x_PM_LS_HL_X2%VSS_8 x_PM_LS_HL_X2%VSS_17 0.264221
R_x_PM_LS_HL_X2%VSS_r29 x_PM_LS_HL_X2%VSS_8 N_VSS_M2_b 0.5016
C_x_PM_LS_HL_X2%3_c0 x_PM_LS_HL_X2%3_30 VSS 0.0123398f
C_x_PM_LS_HL_X2%3_c1 x_PM_LS_HL_X2%3_26 VSS 0.101396f
C_x_PM_LS_HL_X2%3_c2 x_PM_LS_HL_X2%3_22 VSS 0.00528501f
C_x_PM_LS_HL_X2%3_c3 x_PM_LS_HL_X2%3_21 VSS 0.0320142f
C_x_PM_LS_HL_X2%3_c4 x_PM_LS_HL_X2%3_20 VSS 0.0136631f
C_x_PM_LS_HL_X2%3_c5 x_PM_LS_HL_X2%3_19 VSS 0.050435f
C_x_PM_LS_HL_X2%3_c6 N_3_M0_s VSS 0.0150134f
C_x_PM_LS_HL_X2%3_c7 N_3_M2_s VSS 0.0282405f
C_x_PM_LS_HL_X2%3_c8 N_3_M1_g VSS 0.0537765f
C_x_PM_LS_HL_X2%3_c9 N_3_M3_g VSS 0.0541645f
R_x_PM_LS_HL_X2%3_r10 x_PM_LS_HL_X2%3_28 x_PM_LS_HL_X2%3_30 4.42
R_x_PM_LS_HL_X2%3_r11 x_PM_LS_HL_X2%3_26 x_PM_LS_HL_X2%3_28 25.0012
R_x_PM_LS_HL_X2%3_r12 x_PM_LS_HL_X2%3_24 x_PM_LS_HL_X2%3_26 0.963571
R_x_PM_LS_HL_X2%3_r13 x_PM_LS_HL_X2%3_23 x_PM_LS_HL_X2%3_26 1.28929
R_x_PM_LS_HL_X2%3_r14 x_PM_LS_HL_X2%3_21 x_PM_LS_HL_X2%3_24 0.212317
R_x_PM_LS_HL_X2%3_r15 x_PM_LS_HL_X2%3_21 x_PM_LS_HL_X2%3_22 0.895714
R_x_PM_LS_HL_X2%3_r16 x_PM_LS_HL_X2%3_19 x_PM_LS_HL_X2%3_23 0.212317
R_x_PM_LS_HL_X2%3_r17 x_PM_LS_HL_X2%3_19 x_PM_LS_HL_X2%3_20 0.895714
R_x_PM_LS_HL_X2%3_r18 x_PM_LS_HL_X2%3_15 x_PM_LS_HL_X2%3_22 0.212317
R_x_PM_LS_HL_X2%3_r19 x_PM_LS_HL_X2%3_15 N_3_M0_s 0.475
R_x_PM_LS_HL_X2%3_r20 x_PM_LS_HL_X2%3_11 x_PM_LS_HL_X2%3_20 0.212317
R_x_PM_LS_HL_X2%3_r21 x_PM_LS_HL_X2%3_11 N_3_M2_s 0.285
R_x_PM_LS_HL_X2%3_r22 x_PM_LS_HL_X2%3_5 x_PM_LS_HL_X2%3_30 1.95
R_x_PM_LS_HL_X2%3_r23 x_PM_LS_HL_X2%3_5 N_3_M1_g 40.17
R_x_PM_LS_HL_X2%3_r24 x_PM_LS_HL_X2%3_1 x_PM_LS_HL_X2%3_30 1.95
R_x_PM_LS_HL_X2%3_r25 x_PM_LS_HL_X2%3_1 N_3_M3_g 44.85
C_x_PM_LS_HL_X2%A_c0 x_PM_LS_HL_X2%A_14 VSS 0.00694931f
C_x_PM_LS_HL_X2%A_c1 x_PM_LS_HL_X2%A_12 VSS 0.0495782f
C_x_PM_LS_HL_X2%A_c2 N_A_M0_g VSS 0.0641517f
C_x_PM_LS_HL_X2%A_c3 N_A_M2_g VSS 0.0442361f
R_x_PM_LS_HL_X2%A_r4 x_PM_LS_HL_X2%A_14 x_PM_LS_HL_X2%A_18 4.7687
R_x_PM_LS_HL_X2%A_r5 x_PM_LS_HL_X2%A_14 x_PM_LS_HL_X2%A_17 4.7687
R_x_PM_LS_HL_X2%A_r6 x_PM_LS_HL_X2%A_12 x_PM_LS_HL_X2%A_14 25.0012
R_x_PM_LS_HL_X2%A_r7 A x_PM_LS_HL_X2%A_12 0.169643
R_x_PM_LS_HL_X2%A_r8 x_PM_LS_HL_X2%A_18 N_A_M0_g 72.93
R_x_PM_LS_HL_X2%A_r9 x_PM_LS_HL_X2%A_17 N_A_M2_g 40.17
C_x_PM_LS_HL_X2%Z_c0 N_Z_M3_d VSS 0.150105f
R_x_PM_LS_HL_X2%Z_r1 Z N_Z_M1_d 1.10833
R_x_PM_LS_HL_X2%Z_r2 N_Z_M3_d Z 1.045
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_HL_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_HL_X4 VDDL VSS A Z
*.PININFO VDDL:P VSS:G A:I Z:O
*.EQN Z=A
M_M3 N_VDDL_M0_d N_A_M0_g N_3_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=2.3e-07
M_M4 N_Z_M1_d N_3_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=4.15e-07
M_M5 N_VDDL_M2_d N_3_M2_g N_Z_M1_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=4.15e-07
M_M0 N_VSS_M3_d N_A_M3_g N_3_M3_s N_VSS_M3_b NMOS_VTL L=5e-08 W=1.7e-07
M_M1 N_Z_M4_d N_3_M4_g N_VSS_M3_d N_VSS_M3_b NMOS_VTL L=5e-08 W=3.05e-07
M_M2 N_VSS_M5_d N_3_M5_g N_Z_M4_d N_VSS_M3_b NMOS_VTL L=5e-08 W=3.05e-07
C_x_PM_LS_HL_X4%VDDL_c0 x_PM_LS_HL_X4%VDDL_48 VSS 0.00303463f
C_x_PM_LS_HL_X4%VDDL_c1 x_PM_LS_HL_X4%VDDL_47 VSS 0.00295132f
C_x_PM_LS_HL_X4%VDDL_c2 VDDL VSS 0.254713f
C_x_PM_LS_HL_X4%VDDL_c3 x_PM_LS_HL_X4%VDDL_43 VSS 0.0125362f
C_x_PM_LS_HL_X4%VDDL_c4 N_VDDL_M2_d VSS 0.034157f
C_x_PM_LS_HL_X4%VDDL_c5 x_PM_LS_HL_X4%VDDL_33 VSS 0.0193653f
C_x_PM_LS_HL_X4%VDDL_c6 N_VDDL_M0_d VSS 0.0649607f
C_x_PM_LS_HL_X4%VDDL_c7 x_PM_LS_HL_X4%VDDL_27 VSS 0.0176206f
C_x_PM_LS_HL_X4%VDDL_c8 x_PM_LS_HL_X4%VDDL_22 VSS 0.0120441f
C_x_PM_LS_HL_X4%VDDL_c9 x_PM_LS_HL_X4%VDDL_21 VSS 0.240864f
C_x_PM_LS_HL_X4%VDDL_c10 VDDL VSS 0.588991f
C_x_PM_LS_HL_X4%VDDL_c11 N_VDDL_M0_b VSS 0.0372651f
R_x_PM_LS_HL_X4%VDDL_r12 x_PM_LS_HL_X4%VDDL_49 x_PM_LS_HL_X4%VDDL_50 0.469412
R_x_PM_LS_HL_X4%VDDL_r13 x_PM_LS_HL_X4%VDDL_43 x_PM_LS_HL_X4%VDDL_50 0.0782353
R_x_PM_LS_HL_X4%VDDL_r14 x_PM_LS_HL_X4%VDDL_43 VDDL 8.03588
R_x_PM_LS_HL_X4%VDDL_r15 x_PM_LS_HL_X4%VDDL_39 x_PM_LS_HL_X4%VDDL_50 0.095
R_x_PM_LS_HL_X4%VDDL_r16 x_PM_LS_HL_X4%VDDL_35 x_PM_LS_HL_X4%VDDL_49 0.095
R_x_PM_LS_HL_X4%VDDL_r17 x_PM_LS_HL_X4%VDDL_35 N_VDDL_M2_d 1.58786
R_x_PM_LS_HL_X4%VDDL_r18 x_PM_LS_HL_X4%VDDL_34 x_PM_LS_HL_X4%VDDL_48 0.0731438
R_x_PM_LS_HL_X4%VDDL_r19 x_PM_LS_HL_X4%VDDL_33 x_PM_LS_HL_X4%VDDL_49 0.0782353
R_x_PM_LS_HL_X4%VDDL_r20 x_PM_LS_HL_X4%VDDL_33 x_PM_LS_HL_X4%VDDL_34 0.692941
R_x_PM_LS_HL_X4%VDDL_r21 x_PM_LS_HL_X4%VDDL_29 x_PM_LS_HL_X4%VDDL_48 0.145286
R_x_PM_LS_HL_X4%VDDL_r22 x_PM_LS_HL_X4%VDDL_29 N_VDDL_M0_d 1.58786
R_x_PM_LS_HL_X4%VDDL_r23 x_PM_LS_HL_X4%VDDL_28 x_PM_LS_HL_X4%VDDL_47 0.0731438
R_x_PM_LS_HL_X4%VDDL_r24 x_PM_LS_HL_X4%VDDL_27 x_PM_LS_HL_X4%VDDL_48 0.0731438
R_x_PM_LS_HL_X4%VDDL_r25 x_PM_LS_HL_X4%VDDL_27 x_PM_LS_HL_X4%VDDL_28 0.625882
R_x_PM_LS_HL_X4%VDDL_r26 x_PM_LS_HL_X4%VDDL_23 x_PM_LS_HL_X4%VDDL_47 0.145286
R_x_PM_LS_HL_X4%VDDL_r27 x_PM_LS_HL_X4%VDDL_21 x_PM_LS_HL_X4%VDDL_47 0.0731438
R_x_PM_LS_HL_X4%VDDL_r28 x_PM_LS_HL_X4%VDDL_21 x_PM_LS_HL_X4%VDDL_22 7.93529
R_x_PM_LS_HL_X4%VDDL_r29 x_PM_LS_HL_X4%VDDL_13 x_PM_LS_HL_X4%VDDL_22 0.264221
R_x_PM_LS_HL_X4%VDDL_r30 x_PM_LS_HL_X4%VDDL_39 N_VDDL_M0_b 0.827857
R_x_PM_LS_HL_X4%VDDL_r31 x_PM_LS_HL_X4%VDDL_23 N_VDDL_M0_b 0.827857
R_x_PM_LS_HL_X4%VDDL_r32 x_PM_LS_HL_X4%VDDL_13 N_VDDL_M0_b 0.827857
C_x_PM_LS_HL_X4%VSS_c0 x_PM_LS_HL_X4%VSS_48 VSS 0.00280728f
C_x_PM_LS_HL_X4%VSS_c1 x_PM_LS_HL_X4%VSS_47 VSS 0.00292673f
C_x_PM_LS_HL_X4%VSS_c2 VSS VSS 0.254713f
C_x_PM_LS_HL_X4%VSS_c3 x_PM_LS_HL_X4%VSS_43 VSS 0.0123632f
C_x_PM_LS_HL_X4%VSS_c4 N_VSS_M5_d VSS 0.0323724f
C_x_PM_LS_HL_X4%VSS_c5 x_PM_LS_HL_X4%VSS_33 VSS 0.0368367f
C_x_PM_LS_HL_X4%VSS_c6 x_PM_LS_HL_X4%VSS_27 VSS 0.0255588f
C_x_PM_LS_HL_X4%VSS_c7 N_VSS_M3_b VSS 0.0349416f
C_x_PM_LS_HL_X4%VSS_c8 VSS VSS 0.585548f
C_x_PM_LS_HL_X4%VSS_c9 x_PM_LS_HL_X4%VSS_18 VSS 0.0120195f
C_x_PM_LS_HL_X4%VSS_c10 x_PM_LS_HL_X4%VSS_17 VSS 0.240864f
C_x_PM_LS_HL_X4%VSS_c11 N_VSS_M3_d VSS 0.0291703f
R_x_PM_LS_HL_X4%VSS_r12 x_PM_LS_HL_X4%VSS_49 x_PM_LS_HL_X4%VSS_50 0.469412
R_x_PM_LS_HL_X4%VSS_r13 x_PM_LS_HL_X4%VSS_43 x_PM_LS_HL_X4%VSS_50 0.0782353
R_x_PM_LS_HL_X4%VSS_r14 x_PM_LS_HL_X4%VSS_43 VSS 8.00235
R_x_PM_LS_HL_X4%VSS_r15 x_PM_LS_HL_X4%VSS_39 x_PM_LS_HL_X4%VSS_50 0.095
R_x_PM_LS_HL_X4%VSS_r16 x_PM_LS_HL_X4%VSS_35 x_PM_LS_HL_X4%VSS_49 0.095
R_x_PM_LS_HL_X4%VSS_r17 x_PM_LS_HL_X4%VSS_35 N_VSS_M5_d 1.12643
R_x_PM_LS_HL_X4%VSS_r18 x_PM_LS_HL_X4%VSS_34 x_PM_LS_HL_X4%VSS_48 0.0731438
R_x_PM_LS_HL_X4%VSS_r19 x_PM_LS_HL_X4%VSS_33 x_PM_LS_HL_X4%VSS_49 0.0782353
R_x_PM_LS_HL_X4%VSS_r20 x_PM_LS_HL_X4%VSS_33 x_PM_LS_HL_X4%VSS_34 0.692941
R_x_PM_LS_HL_X4%VSS_r21 x_PM_LS_HL_X4%VSS_29 x_PM_LS_HL_X4%VSS_48 0.145286
R_x_PM_LS_HL_X4%VSS_r22 x_PM_LS_HL_X4%VSS_28 x_PM_LS_HL_X4%VSS_47 0.0731438
R_x_PM_LS_HL_X4%VSS_r23 x_PM_LS_HL_X4%VSS_27 x_PM_LS_HL_X4%VSS_48 0.0731438
R_x_PM_LS_HL_X4%VSS_r24 x_PM_LS_HL_X4%VSS_27 x_PM_LS_HL_X4%VSS_28 0.625882
R_x_PM_LS_HL_X4%VSS_r25 x_PM_LS_HL_X4%VSS_39 N_VSS_M3_b 0.502143
R_x_PM_LS_HL_X4%VSS_r26 x_PM_LS_HL_X4%VSS_23 x_PM_LS_HL_X4%VSS_47 0.145286
R_x_PM_LS_HL_X4%VSS_r27 x_PM_LS_HL_X4%VSS_23 N_VSS_M3_b 0.502143
R_x_PM_LS_HL_X4%VSS_r28 x_PM_LS_HL_X4%VSS_17 x_PM_LS_HL_X4%VSS_47 0.0731438
R_x_PM_LS_HL_X4%VSS_r29 x_PM_LS_HL_X4%VSS_17 x_PM_LS_HL_X4%VSS_18 7.93529
R_x_PM_LS_HL_X4%VSS_r30 x_PM_LS_HL_X4%VSS_9 x_PM_LS_HL_X4%VSS_18 0.264221
R_x_PM_LS_HL_X4%VSS_r31 x_PM_LS_HL_X4%VSS_9 N_VSS_M3_b 0.5016
R_x_PM_LS_HL_X4%VSS_r32 x_PM_LS_HL_X4%VSS_29 N_VSS_M3_d 0.366429
C_x_PM_LS_HL_X4%3_c0 x_PM_LS_HL_X4%3_37 VSS 0.082947f
C_x_PM_LS_HL_X4%3_c1 x_PM_LS_HL_X4%3_33 VSS 0.00831941f
C_x_PM_LS_HL_X4%3_c2 x_PM_LS_HL_X4%3_32 VSS 0.0421501f
C_x_PM_LS_HL_X4%3_c3 x_PM_LS_HL_X4%3_31 VSS 0.0134469f
C_x_PM_LS_HL_X4%3_c4 x_PM_LS_HL_X4%3_30 VSS 0.0498581f
C_x_PM_LS_HL_X4%3_c5 N_3_M0_s VSS 0.0401093f
C_x_PM_LS_HL_X4%3_c6 N_3_M3_s VSS 0.0230242f
C_x_PM_LS_HL_X4%3_c7 x_PM_LS_HL_X4%3_19 VSS 0.00330952f
C_x_PM_LS_HL_X4%3_c8 N_3_M2_g VSS 0.0416209f
C_x_PM_LS_HL_X4%3_c9 N_3_M5_g VSS 0.0369185f
C_x_PM_LS_HL_X4%3_c10 x_PM_LS_HL_X4%3_10 VSS 0.00699102f
C_x_PM_LS_HL_X4%3_c11 x_PM_LS_HL_X4%3_9 VSS 0.0126095f
C_x_PM_LS_HL_X4%3_c12 N_3_M1_g VSS 0.0366857f
C_x_PM_LS_HL_X4%3_c13 N_3_M4_g VSS 0.0307613f
R_x_PM_LS_HL_X4%3_r14 x_PM_LS_HL_X4%3_39 x_PM_LS_HL_X4%3_41 3.9
R_x_PM_LS_HL_X4%3_r15 x_PM_LS_HL_X4%3_37 x_PM_LS_HL_X4%3_39 25.0012
R_x_PM_LS_HL_X4%3_r16 x_PM_LS_HL_X4%3_35 x_PM_LS_HL_X4%3_37 0.746429
R_x_PM_LS_HL_X4%3_r17 x_PM_LS_HL_X4%3_34 x_PM_LS_HL_X4%3_37 1.01786
R_x_PM_LS_HL_X4%3_r18 x_PM_LS_HL_X4%3_32 x_PM_LS_HL_X4%3_35 0.212317
R_x_PM_LS_HL_X4%3_r19 x_PM_LS_HL_X4%3_32 x_PM_LS_HL_X4%3_33 0.922857
R_x_PM_LS_HL_X4%3_r20 x_PM_LS_HL_X4%3_30 x_PM_LS_HL_X4%3_34 0.212317
R_x_PM_LS_HL_X4%3_r21 x_PM_LS_HL_X4%3_30 x_PM_LS_HL_X4%3_31 0.922857
R_x_PM_LS_HL_X4%3_r22 x_PM_LS_HL_X4%3_26 x_PM_LS_HL_X4%3_33 0.212317
R_x_PM_LS_HL_X4%3_r23 x_PM_LS_HL_X4%3_26 N_3_M0_s 1.39786
R_x_PM_LS_HL_X4%3_r24 x_PM_LS_HL_X4%3_22 x_PM_LS_HL_X4%3_31 0.212317
R_x_PM_LS_HL_X4%3_r25 x_PM_LS_HL_X4%3_22 N_3_M3_s 0.203571
R_x_PM_LS_HL_X4%3_r26 x_PM_LS_HL_X4%3_15 x_PM_LS_HL_X4%3_19 4.56151
R_x_PM_LS_HL_X4%3_r27 x_PM_LS_HL_X4%3_15 N_3_M2_g 42.51
R_x_PM_LS_HL_X4%3_r28 x_PM_LS_HL_X4%3_11 x_PM_LS_HL_X4%3_19 4.56151
R_x_PM_LS_HL_X4%3_r29 x_PM_LS_HL_X4%3_11 N_3_M5_g 37.05
R_x_PM_LS_HL_X4%3_r30 x_PM_LS_HL_X4%3_10 x_PM_LS_HL_X4%3_41 2.6
R_x_PM_LS_HL_X4%3_r31 x_PM_LS_HL_X4%3_9 x_PM_LS_HL_X4%3_19 0.043368
R_x_PM_LS_HL_X4%3_r32 x_PM_LS_HL_X4%3_9 x_PM_LS_HL_X4%3_10 14.56
R_x_PM_LS_HL_X4%3_r33 x_PM_LS_HL_X4%3_5 x_PM_LS_HL_X4%3_41 1.95
R_x_PM_LS_HL_X4%3_r34 x_PM_LS_HL_X4%3_5 N_3_M1_g 42.51
R_x_PM_LS_HL_X4%3_r35 x_PM_LS_HL_X4%3_1 x_PM_LS_HL_X4%3_41 1.95
R_x_PM_LS_HL_X4%3_r36 x_PM_LS_HL_X4%3_1 N_3_M4_g 37.05
C_x_PM_LS_HL_X4%A_c0 x_PM_LS_HL_X4%A_14 VSS 0.00723213f
C_x_PM_LS_HL_X4%A_c1 x_PM_LS_HL_X4%A_12 VSS 0.0533008f
C_x_PM_LS_HL_X4%A_c2 N_A_M0_g VSS 0.0657807f
C_x_PM_LS_HL_X4%A_c3 N_A_M3_g VSS 0.0443432f
R_x_PM_LS_HL_X4%A_r4 x_PM_LS_HL_X4%A_14 x_PM_LS_HL_X4%A_18 4.7687
R_x_PM_LS_HL_X4%A_r5 x_PM_LS_HL_X4%A_14 x_PM_LS_HL_X4%A_17 4.7687
R_x_PM_LS_HL_X4%A_r6 x_PM_LS_HL_X4%A_12 x_PM_LS_HL_X4%A_14 25.0012
R_x_PM_LS_HL_X4%A_r7 A x_PM_LS_HL_X4%A_12 0.169643
R_x_PM_LS_HL_X4%A_r8 x_PM_LS_HL_X4%A_18 N_A_M0_g 64.74
R_x_PM_LS_HL_X4%A_r9 x_PM_LS_HL_X4%A_17 N_A_M3_g 39.78
C_x_PM_LS_HL_X4%Z_c0 N_Z_M4_d VSS 0.19855f
R_x_PM_LS_HL_X4%Z_r1 Z N_Z_M1_d 1.59389
R_x_PM_LS_HL_X4%Z_r2 N_Z_M4_d Z 0.559444
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_LHEN_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LHEN_X1 VDD VSS A VDDL ISOLN Z
*.PININFO VDD:P VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M9 N_VDDL_M0_d N_A_M0_g N_4_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.9e-07
M_M10 N_6_M1_d N_4_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.9e-07
M_M11 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M12 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M13 N_10_M4_d N_ISOLN_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=2.3e-07
M_M14 N_VDD_M5_d N_8_M5_g N_10_M4_d N_VDD_M2_b PMOS_VTL L=5e-08 W=2.3e-07
M_M15 N_Z_M6_d N_10_M6_g N_VDD_M5_d N_VDD_M2_b PMOS_VTL L=5e-08 W=2.3e-07
M_M0 N_VSS_M7_d N_A_M7_g N_4_M7_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M8_d N_4_M8_g N_VSS_M7_d N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M2 12 N_ISOLN_M9_g N_VSS_M9_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_7_M10_d N_6_M10_g 12 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M4 13 N_4_M11_g N_8_M11_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M5 N_VSS_M12_d N_ISOLN_M12_g 13 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M6 14 N_ISOLN_M13_g N_10_M13_s N_VSS_M7_b NMOS_VTL L=5e-08 W=1.4e-07
M_M7 N_VSS_M14_d N_8_M14_g 14 N_VSS_M7_b NMOS_VTL L=5e-08 W=1.4e-07
M_M8 N_Z_M15_d N_10_M15_g N_VSS_M14_d N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
C_x_PM_LS_LHEN_X1%VDD_c0 x_PM_LS_LHEN_X1%VDD_49 VSS 0.0228456f
C_x_PM_LS_LHEN_X1%VDD_c1 x_PM_LS_LHEN_X1%VDD_46 VSS 0.00570267f
C_x_PM_LS_LHEN_X1%VDD_c2 x_PM_LS_LHEN_X1%VDD_45 VSS 0.0036036f
C_x_PM_LS_LHEN_X1%VDD_c3 x_PM_LS_LHEN_X1%VDD_44 VSS 0.00292673f
C_x_PM_LS_LHEN_X1%VDD_c4 x_PM_LS_LHEN_X1%VDD_43 VSS 0.0108319f
C_x_PM_LS_LHEN_X1%VDD_c5 x_PM_LS_LHEN_X1%VDD_42 VSS 0.2334f
C_x_PM_LS_LHEN_X1%VDD_c6 x_PM_LS_LHEN_X1%VDD_33 VSS 0.261446f
C_x_PM_LS_LHEN_X1%VDD_c7 x_PM_LS_LHEN_X1%VDD_30 VSS 0.0668431f
C_x_PM_LS_LHEN_X1%VDD_c8 x_PM_LS_LHEN_X1%VDD_27 VSS 0.0210677f
C_x_PM_LS_LHEN_X1%VDD_c9 N_VDD_M4_s VSS 0.0303685f
C_x_PM_LS_LHEN_X1%VDD_c10 x_PM_LS_LHEN_X1%VDD_21 VSS 0.0385059f
C_x_PM_LS_LHEN_X1%VDD_c11 N_VDD_M2_d VSS 0.0293886f
C_x_PM_LS_LHEN_X1%VDD_c12 x_PM_LS_LHEN_X1%VDD_15 VSS 0.12287f
C_x_PM_LS_LHEN_X1%VDD_c13 x_PM_LS_LHEN_X1%VDD_14 VSS 0.0192462f
C_x_PM_LS_LHEN_X1%VDD_c14 x_PM_LS_LHEN_X1%VDD_10 VSS 0.706493f
R_x_PM_LS_LHEN_X1%VDD_r15 N_VDD_M2_b x_PM_LS_LHEN_X1%VDD_49 0.13879
R_x_PM_LS_LHEN_X1%VDD_r16 N_VDD_M2_b x_PM_LS_LHEN_X1%VDD_43 0.138595
R_x_PM_LS_LHEN_X1%VDD_r17 N_VDD_M2_b x_PM_LS_LHEN_X1%VDD_42 0.138985
R_x_PM_LS_LHEN_X1%VDD_r18 N_VDD_M2_b x_PM_LS_LHEN_X1%VDD_33 0.13879
R_x_PM_LS_LHEN_X1%VDD_r19 x_PM_LS_LHEN_X1%VDD_33 VDD 3.84471
R_x_PM_LS_LHEN_X1%VDD_r20 x_PM_LS_LHEN_X1%VDD_32 x_PM_LS_LHEN_X1%VDD_46 0.132285
R_x_PM_LS_LHEN_X1%VDD_r21 x_PM_LS_LHEN_X1%VDD_49 x_PM_LS_LHEN_X1%VDD_32 0.558824
R_x_PM_LS_LHEN_X1%VDD_r22 x_PM_LS_LHEN_X1%VDD_30 x_PM_LS_LHEN_X1%VDD_46 0.0680382
R_x_PM_LS_LHEN_X1%VDD_r23 N_VDD_M5_d x_PM_LS_LHEN_X1%VDD_30 0.502102
R_x_PM_LS_LHEN_X1%VDD_r24 x_PM_LS_LHEN_X1%VDD_28 x_PM_LS_LHEN_X1%VDD_45 0.087517
R_x_PM_LS_LHEN_X1%VDD_r25 x_PM_LS_LHEN_X1%VDD_27 x_PM_LS_LHEN_X1%VDD_46 0.132285
R_x_PM_LS_LHEN_X1%VDD_r26 x_PM_LS_LHEN_X1%VDD_27 x_PM_LS_LHEN_X1%VDD_28 0.625882
R_x_PM_LS_LHEN_X1%VDD_r27 x_PM_LS_LHEN_X1%VDD_23 x_PM_LS_LHEN_X1%VDD_45 0.122195
R_x_PM_LS_LHEN_X1%VDD_r28 x_PM_LS_LHEN_X1%VDD_23 N_VDD_M4_s 0.882941
R_x_PM_LS_LHEN_X1%VDD_r29 x_PM_LS_LHEN_X1%VDD_22 x_PM_LS_LHEN_X1%VDD_44 0.0731438
R_x_PM_LS_LHEN_X1%VDD_r30 x_PM_LS_LHEN_X1%VDD_21 x_PM_LS_LHEN_X1%VDD_45 0.087517
R_x_PM_LS_LHEN_X1%VDD_r31 x_PM_LS_LHEN_X1%VDD_21 x_PM_LS_LHEN_X1%VDD_22 1.02824
R_x_PM_LS_LHEN_X1%VDD_r32 x_PM_LS_LHEN_X1%VDD_17 x_PM_LS_LHEN_X1%VDD_44 0.145286
R_x_PM_LS_LHEN_X1%VDD_r33 x_PM_LS_LHEN_X1%VDD_17 N_VDD_M2_d 0.502143
R_x_PM_LS_LHEN_X1%VDD_r34 x_PM_LS_LHEN_X1%VDD_15 x_PM_LS_LHEN_X1%VDD_44 0.0731438
R_x_PM_LS_LHEN_X1%VDD_r35 x_PM_LS_LHEN_X1%VDD_15 x_PM_LS_LHEN_X1%VDD_43 3.28588
R_x_PM_LS_LHEN_X1%VDD_r36 x_PM_LS_LHEN_X1%VDD_14 N_VDD_M2_b 0.140282
R_x_PM_LS_LHEN_X1%VDD_r37 x_PM_LS_LHEN_X1%VDD_42 x_PM_LS_LHEN_X1%VDD_14 7.68941
R_x_PM_LS_LHEN_X1%VDD_r38 x_PM_LS_LHEN_X1%VDD_10 VDD 11.0647
C_x_PM_LS_LHEN_X1%VSS_c0 x_PM_LS_LHEN_X1%VSS_57 VSS 0.00294746f
C_x_PM_LS_LHEN_X1%VSS_c1 x_PM_LS_LHEN_X1%VSS_56 VSS 0.00276597f
C_x_PM_LS_LHEN_X1%VSS_c2 x_PM_LS_LHEN_X1%VSS_55 VSS 0.00276597f
C_x_PM_LS_LHEN_X1%VSS_c3 x_PM_LS_LHEN_X1%VSS_54 VSS 0.00293741f
C_x_PM_LS_LHEN_X1%VSS_c4 x_PM_LS_LHEN_X1%VSS_52 VSS 0.2334f
C_x_PM_LS_LHEN_X1%VSS_c5 N_VSS_M7_b VSS 0.261464f
C_x_PM_LS_LHEN_X1%VSS_c6 x_PM_LS_LHEN_X1%VSS_42 VSS 0.0316988f
C_x_PM_LS_LHEN_X1%VSS_c7 N_VSS_M14_d VSS 0.0382121f
C_x_PM_LS_LHEN_X1%VSS_c8 x_PM_LS_LHEN_X1%VSS_36 VSS 0.0434429f
C_x_PM_LS_LHEN_X1%VSS_c9 N_VSS_M12_d VSS 0.0332966f
C_x_PM_LS_LHEN_X1%VSS_c10 x_PM_LS_LHEN_X1%VSS_28 VSS 0.0969274f
C_x_PM_LS_LHEN_X1%VSS_c11 N_VSS_M9_s VSS 0.0465138f
C_x_PM_LS_LHEN_X1%VSS_c12 x_PM_LS_LHEN_X1%VSS_22 VSS 0.034078f
C_x_PM_LS_LHEN_X1%VSS_c13 N_VSS_M7_d VSS 0.0423476f
C_x_PM_LS_LHEN_X1%VSS_c14 x_PM_LS_LHEN_X1%VSS_17 VSS 0.0106068f
C_x_PM_LS_LHEN_X1%VSS_c15 x_PM_LS_LHEN_X1%VSS_16 VSS 0.0560111f
C_x_PM_LS_LHEN_X1%VSS_c16 x_PM_LS_LHEN_X1%VSS_13 VSS 0.706493f
C_x_PM_LS_LHEN_X1%VSS_c17 x_PM_LS_LHEN_X1%VSS_12 VSS 0.0192462f
R_x_PM_LS_LHEN_X1%VSS_r18 N_VSS_M7_b x_PM_LS_LHEN_X1%VSS_52 0.138985
R_x_PM_LS_LHEN_X1%VSS_r19 x_PM_LS_LHEN_X1%VSS_43 x_PM_LS_LHEN_X1%VSS_57 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r20 N_VSS_M7_b x_PM_LS_LHEN_X1%VSS_42 0.13879
R_x_PM_LS_LHEN_X1%VSS_r21 x_PM_LS_LHEN_X1%VSS_42 x_PM_LS_LHEN_X1%VSS_43 0.637059
R_x_PM_LS_LHEN_X1%VSS_r22 x_PM_LS_LHEN_X1%VSS_38 x_PM_LS_LHEN_X1%VSS_57 0.145286
R_x_PM_LS_LHEN_X1%VSS_r23 x_PM_LS_LHEN_X1%VSS_38 N_VSS_M14_d 0.773571
R_x_PM_LS_LHEN_X1%VSS_r24 x_PM_LS_LHEN_X1%VSS_37 x_PM_LS_LHEN_X1%VSS_56 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r25 x_PM_LS_LHEN_X1%VSS_36 x_PM_LS_LHEN_X1%VSS_57 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r26 x_PM_LS_LHEN_X1%VSS_36 x_PM_LS_LHEN_X1%VSS_37 1.06176
R_x_PM_LS_LHEN_X1%VSS_r27 x_PM_LS_LHEN_X1%VSS_32 x_PM_LS_LHEN_X1%VSS_56 0.145286
R_x_PM_LS_LHEN_X1%VSS_r28 x_PM_LS_LHEN_X1%VSS_32 N_VSS_M12_d 0.909286
R_x_PM_LS_LHEN_X1%VSS_r29 x_PM_LS_LHEN_X1%VSS_29 x_PM_LS_LHEN_X1%VSS_55 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r30 x_PM_LS_LHEN_X1%VSS_29 VSS 0.793529
R_x_PM_LS_LHEN_X1%VSS_r31 x_PM_LS_LHEN_X1%VSS_28 x_PM_LS_LHEN_X1%VSS_56 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r32 x_PM_LS_LHEN_X1%VSS_28 VSS 1.06176
R_x_PM_LS_LHEN_X1%VSS_r33 x_PM_LS_LHEN_X1%VSS_24 x_PM_LS_LHEN_X1%VSS_55 0.145286
R_x_PM_LS_LHEN_X1%VSS_r34 x_PM_LS_LHEN_X1%VSS_24 N_VSS_M9_s 0.909286
R_x_PM_LS_LHEN_X1%VSS_r35 x_PM_LS_LHEN_X1%VSS_23 x_PM_LS_LHEN_X1%VSS_54 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r36 x_PM_LS_LHEN_X1%VSS_22 x_PM_LS_LHEN_X1%VSS_55 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r37 x_PM_LS_LHEN_X1%VSS_22 x_PM_LS_LHEN_X1%VSS_23 0.637059
R_x_PM_LS_LHEN_X1%VSS_r38 x_PM_LS_LHEN_X1%VSS_18 x_PM_LS_LHEN_X1%VSS_54 0.145286
R_x_PM_LS_LHEN_X1%VSS_r39 x_PM_LS_LHEN_X1%VSS_18 N_VSS_M7_d 0.637857
R_x_PM_LS_LHEN_X1%VSS_r40 N_VSS_M7_b x_PM_LS_LHEN_X1%VSS_17 0.138595
R_x_PM_LS_LHEN_X1%VSS_r41 x_PM_LS_LHEN_X1%VSS_16 x_PM_LS_LHEN_X1%VSS_54 0.0731438
R_x_PM_LS_LHEN_X1%VSS_r42 x_PM_LS_LHEN_X1%VSS_16 x_PM_LS_LHEN_X1%VSS_17 1.33
R_x_PM_LS_LHEN_X1%VSS_r43 x_PM_LS_LHEN_X1%VSS_13 VSS 11.0647
R_x_PM_LS_LHEN_X1%VSS_r44 x_PM_LS_LHEN_X1%VSS_12 N_VSS_M7_b 0.140282
R_x_PM_LS_LHEN_X1%VSS_r45 x_PM_LS_LHEN_X1%VSS_52 x_PM_LS_LHEN_X1%VSS_12 7.68941
C_x_PM_LS_LHEN_X1%A_c0 x_PM_LS_LHEN_X1%A_21 VSS 0.0153158f
C_x_PM_LS_LHEN_X1%A_c1 x_PM_LS_LHEN_X1%A_14 VSS 0.0591707f
C_x_PM_LS_LHEN_X1%A_c2 x_PM_LS_LHEN_X1%A_13 VSS 0.00483269f
C_x_PM_LS_LHEN_X1%A_c3 A VSS 0.0210652f
C_x_PM_LS_LHEN_X1%A_c4 N_A_M0_g VSS 0.0360182f
C_x_PM_LS_LHEN_X1%A_c5 N_A_M7_g VSS 0.0433247f
R_x_PM_LS_LHEN_X1%A_r6 x_PM_LS_LHEN_X1%A_20 x_PM_LS_LHEN_X1%A_21 3.64
R_x_PM_LS_LHEN_X1%A_r7 x_PM_LS_LHEN_X1%A_16 x_PM_LS_LHEN_X1%A_20 2.86
R_x_PM_LS_LHEN_X1%A_r8 x_PM_LS_LHEN_X1%A_14 x_PM_LS_LHEN_X1%A_16 25.0012
R_x_PM_LS_LHEN_X1%A_r9 x_PM_LS_LHEN_X1%A_13 x_PM_LS_LHEN_X1%A_14 0.773571
R_x_PM_LS_LHEN_X1%A_r10 x_PM_LS_LHEN_X1%A_9 x_PM_LS_LHEN_X1%A_13 0.212317
R_x_PM_LS_LHEN_X1%A_r11 x_PM_LS_LHEN_X1%A_9 A 0.488571
R_x_PM_LS_LHEN_X1%A_r12 x_PM_LS_LHEN_X1%A_5 x_PM_LS_LHEN_X1%A_21 1.95
R_x_PM_LS_LHEN_X1%A_r13 x_PM_LS_LHEN_X1%A_5 N_A_M0_g 27.3
R_x_PM_LS_LHEN_X1%A_r14 x_PM_LS_LHEN_X1%A_1 x_PM_LS_LHEN_X1%A_20 1.95
R_x_PM_LS_LHEN_X1%A_r15 x_PM_LS_LHEN_X1%A_1 N_A_M7_g 39.78
C_x_PM_LS_LHEN_X1%4_c0 x_PM_LS_LHEN_X1%4_36 VSS 0.0368741f
C_x_PM_LS_LHEN_X1%4_c1 x_PM_LS_LHEN_X1%4_34 VSS 0.0517899f
C_x_PM_LS_LHEN_X1%4_c2 x_PM_LS_LHEN_X1%4_29 VSS 0.0581305f
C_x_PM_LS_LHEN_X1%4_c3 x_PM_LS_LHEN_X1%4_28 VSS 0.0175788f
C_x_PM_LS_LHEN_X1%4_c4 x_PM_LS_LHEN_X1%4_27 VSS 0.0517025f
C_x_PM_LS_LHEN_X1%4_c5 N_4_M7_s VSS 0.0342321f
C_x_PM_LS_LHEN_X1%4_c6 x_PM_LS_LHEN_X1%4_17 VSS 0.0207569f
C_x_PM_LS_LHEN_X1%4_c7 N_4_M11_g VSS 0.0486877f
C_x_PM_LS_LHEN_X1%4_c8 x_PM_LS_LHEN_X1%4_11 VSS 0.0635209f
C_x_PM_LS_LHEN_X1%4_c9 x_PM_LS_LHEN_X1%4_10 VSS 0.00990495f
C_x_PM_LS_LHEN_X1%4_c10 x_PM_LS_LHEN_X1%4_9 VSS 0.0313736f
C_x_PM_LS_LHEN_X1%4_c11 N_4_M1_g VSS 0.0336012f
C_x_PM_LS_LHEN_X1%4_c12 N_4_M8_g VSS 0.0381778f
R_x_PM_LS_LHEN_X1%4_r13 x_PM_LS_LHEN_X1%4_43 x_PM_LS_LHEN_X1%4_44 3.64
R_x_PM_LS_LHEN_X1%4_r14 x_PM_LS_LHEN_X1%4_41 x_PM_LS_LHEN_X1%4_43 1.82
R_x_PM_LS_LHEN_X1%4_r15 x_PM_LS_LHEN_X1%4_36 N_4_M0_s 0.176429
R_x_PM_LS_LHEN_X1%4_r16 x_PM_LS_LHEN_X1%4_34 x_PM_LS_LHEN_X1%4_41 25.0012
R_x_PM_LS_LHEN_X1%4_r17 x_PM_LS_LHEN_X1%4_32 x_PM_LS_LHEN_X1%4_34 0.637857
R_x_PM_LS_LHEN_X1%4_r18 x_PM_LS_LHEN_X1%4_31 x_PM_LS_LHEN_X1%4_34 0.447857
R_x_PM_LS_LHEN_X1%4_r19 x_PM_LS_LHEN_X1%4_30 x_PM_LS_LHEN_X1%4_36 0.095
R_x_PM_LS_LHEN_X1%4_r20 x_PM_LS_LHEN_X1%4_29 x_PM_LS_LHEN_X1%4_32 0.212317
R_x_PM_LS_LHEN_X1%4_r21 x_PM_LS_LHEN_X1%4_29 x_PM_LS_LHEN_X1%4_30 0.841429
R_x_PM_LS_LHEN_X1%4_r22 x_PM_LS_LHEN_X1%4_27 x_PM_LS_LHEN_X1%4_31 0.212317
R_x_PM_LS_LHEN_X1%4_r23 x_PM_LS_LHEN_X1%4_27 x_PM_LS_LHEN_X1%4_28 1.03143
R_x_PM_LS_LHEN_X1%4_r24 x_PM_LS_LHEN_X1%4_23 x_PM_LS_LHEN_X1%4_28 0.212317
R_x_PM_LS_LHEN_X1%4_r25 x_PM_LS_LHEN_X1%4_23 N_4_M7_s 0.637857
R_x_PM_LS_LHEN_X1%4_r26 x_PM_LS_LHEN_X1%4_17 x_PM_LS_LHEN_X1%4_19 10.92
R_x_PM_LS_LHEN_X1%4_r27 x_PM_LS_LHEN_X1%4_13 N_4_M11_g 46.02
R_x_PM_LS_LHEN_X1%4_r28 x_PM_LS_LHEN_X1%4_12 x_PM_LS_LHEN_X1%4_19 1.95
R_x_PM_LS_LHEN_X1%4_r29 x_PM_LS_LHEN_X1%4_11 x_PM_LS_LHEN_X1%4_13 4.58872
R_x_PM_LS_LHEN_X1%4_r30 x_PM_LS_LHEN_X1%4_11 x_PM_LS_LHEN_X1%4_12 49.92
R_x_PM_LS_LHEN_X1%4_r31 x_PM_LS_LHEN_X1%4_10 x_PM_LS_LHEN_X1%4_44 2.6
R_x_PM_LS_LHEN_X1%4_r32 x_PM_LS_LHEN_X1%4_9 x_PM_LS_LHEN_X1%4_17 1.95
R_x_PM_LS_LHEN_X1%4_r33 x_PM_LS_LHEN_X1%4_9 x_PM_LS_LHEN_X1%4_10 24.96
R_x_PM_LS_LHEN_X1%4_r34 x_PM_LS_LHEN_X1%4_5 x_PM_LS_LHEN_X1%4_44 1.95
R_x_PM_LS_LHEN_X1%4_r35 x_PM_LS_LHEN_X1%4_5 N_4_M1_g 29.64
R_x_PM_LS_LHEN_X1%4_r36 x_PM_LS_LHEN_X1%4_1 x_PM_LS_LHEN_X1%4_43 1.95
R_x_PM_LS_LHEN_X1%4_r37 x_PM_LS_LHEN_X1%4_1 N_4_M8_g 37.44
C_x_PM_LS_LHEN_X1%VDDL_c0 VDDL VSS 0.0605428f
C_x_PM_LS_LHEN_X1%VDDL_c1 x_PM_LS_LHEN_X1%VDDL_6 VSS 0.0487622f
R_x_PM_LS_LHEN_X1%VDDL_r2 N_VDDL_M0_b VDDL 0.20425
R_x_PM_LS_LHEN_X1%VDDL_r3 x_PM_LS_LHEN_X1%VDDL_6 N_VDDL_M0_b 0.095
R_x_PM_LS_LHEN_X1%VDDL_r4 N_VDDL_M0_d x_PM_LS_LHEN_X1%VDDL_6 0.347287
C_x_PM_LS_LHEN_X1%6_c0 x_PM_LS_LHEN_X1%6_28 VSS 0.0133857f
C_x_PM_LS_LHEN_X1%6_c1 x_PM_LS_LHEN_X1%6_25 VSS 0.019214f
C_x_PM_LS_LHEN_X1%6_c2 x_PM_LS_LHEN_X1%6_23 VSS 0.047608f
C_x_PM_LS_LHEN_X1%6_c3 x_PM_LS_LHEN_X1%6_17 VSS 0.022532f
C_x_PM_LS_LHEN_X1%6_c4 x_PM_LS_LHEN_X1%6_13 VSS 0.0538994f
C_x_PM_LS_LHEN_X1%6_c5 N_6_M1_d VSS 0.0399906f
C_x_PM_LS_LHEN_X1%6_c6 x_PM_LS_LHEN_X1%6_8 VSS 0.0360895f
C_x_PM_LS_LHEN_X1%6_c7 N_6_M10_g VSS 0.024286f
R_x_PM_LS_LHEN_X1%6_r8 x_PM_LS_LHEN_X1%6_26 x_PM_LS_LHEN_X1%6_28 3.9
R_x_PM_LS_LHEN_X1%6_r9 N_6_M8_d x_PM_LS_LHEN_X1%6_23 0.176429
R_x_PM_LS_LHEN_X1%6_r10 x_PM_LS_LHEN_X1%6_17 x_PM_LS_LHEN_X1%6_26 25.0012
R_x_PM_LS_LHEN_X1%6_r11 x_PM_LS_LHEN_X1%6_15 x_PM_LS_LHEN_X1%6_17 0.257857
R_x_PM_LS_LHEN_X1%6_r12 x_PM_LS_LHEN_X1%6_14 x_PM_LS_LHEN_X1%6_25 0.0418175
R_x_PM_LS_LHEN_X1%6_r13 x_PM_LS_LHEN_X1%6_13 x_PM_LS_LHEN_X1%6_15 0.212317
R_x_PM_LS_LHEN_X1%6_r14 x_PM_LS_LHEN_X1%6_13 x_PM_LS_LHEN_X1%6_14 1.65571
R_x_PM_LS_LHEN_X1%6_r15 x_PM_LS_LHEN_X1%6_9 x_PM_LS_LHEN_X1%6_25 0.160909
R_x_PM_LS_LHEN_X1%6_r16 x_PM_LS_LHEN_X1%6_9 N_6_M1_d 0.882143
R_x_PM_LS_LHEN_X1%6_r17 x_PM_LS_LHEN_X1%6_8 x_PM_LS_LHEN_X1%6_25 0.160909
R_x_PM_LS_LHEN_X1%6_r18 x_PM_LS_LHEN_X1%6_7 x_PM_LS_LHEN_X1%6_23 0.095
R_x_PM_LS_LHEN_X1%6_r19 x_PM_LS_LHEN_X1%6_7 x_PM_LS_LHEN_X1%6_8 1.11286
R_x_PM_LS_LHEN_X1%6_r20 x_PM_LS_LHEN_X1%6_1 x_PM_LS_LHEN_X1%6_28 1.95
R_x_PM_LS_LHEN_X1%6_r21 x_PM_LS_LHEN_X1%6_1 N_6_M10_g 14.82
C_x_PM_LS_LHEN_X1%7_c0 x_PM_LS_LHEN_X1%7_23 VSS 0.0182621f
C_x_PM_LS_LHEN_X1%7_c1 x_PM_LS_LHEN_X1%7_20 VSS 0.0058493f
C_x_PM_LS_LHEN_X1%7_c2 x_PM_LS_LHEN_X1%7_16 VSS 0.0463213f
C_x_PM_LS_LHEN_X1%7_c3 N_7_M2_s VSS 0.0614608f
C_x_PM_LS_LHEN_X1%7_c4 N_7_M10_d VSS 0.118232f
C_x_PM_LS_LHEN_X1%7_c5 N_7_M3_g VSS 0.0532827f
R_x_PM_LS_LHEN_X1%7_r6 x_PM_LS_LHEN_X1%7_18 x_PM_LS_LHEN_X1%7_23 7.02
R_x_PM_LS_LHEN_X1%7_r7 x_PM_LS_LHEN_X1%7_16 x_PM_LS_LHEN_X1%7_18 25.0012
R_x_PM_LS_LHEN_X1%7_r8 x_PM_LS_LHEN_X1%7_15 x_PM_LS_LHEN_X1%7_20 0.0418175
R_x_PM_LS_LHEN_X1%7_r9 x_PM_LS_LHEN_X1%7_15 x_PM_LS_LHEN_X1%7_16 0.773571
R_x_PM_LS_LHEN_X1%7_r10 x_PM_LS_LHEN_X1%7_11 x_PM_LS_LHEN_X1%7_20 0.160909
R_x_PM_LS_LHEN_X1%7_r11 x_PM_LS_LHEN_X1%7_7 x_PM_LS_LHEN_X1%7_20 0.160909
R_x_PM_LS_LHEN_X1%7_r12 x_PM_LS_LHEN_X1%7_7 N_7_M2_s 1.72357
R_x_PM_LS_LHEN_X1%7_r13 x_PM_LS_LHEN_X1%7_11 N_7_M10_d 2.83643
R_x_PM_LS_LHEN_X1%7_r14 x_PM_LS_LHEN_X1%7_1 x_PM_LS_LHEN_X1%7_23 1.95
R_x_PM_LS_LHEN_X1%7_r15 x_PM_LS_LHEN_X1%7_1 N_7_M3_g 53.43
C_x_PM_LS_LHEN_X1%8_c0 x_PM_LS_LHEN_X1%8_42 VSS 0.0107471f
C_x_PM_LS_LHEN_X1%8_c1 x_PM_LS_LHEN_X1%8_35 VSS 0.00577163f
C_x_PM_LS_LHEN_X1%8_c2 x_PM_LS_LHEN_X1%8_32 VSS 0.125784f
C_x_PM_LS_LHEN_X1%8_c3 N_8_M3_d VSS 0.0308929f
C_x_PM_LS_LHEN_X1%8_c4 x_PM_LS_LHEN_X1%8_25 VSS 0.0342081f
C_x_PM_LS_LHEN_X1%8_c5 x_PM_LS_LHEN_X1%8_23 VSS 0.0212189f
C_x_PM_LS_LHEN_X1%8_c6 x_PM_LS_LHEN_X1%8_22 VSS 0.011687f
C_x_PM_LS_LHEN_X1%8_c7 N_8_M11_s VSS 0.0638981f
C_x_PM_LS_LHEN_X1%8_c8 x_PM_LS_LHEN_X1%8_17 VSS 0.0842411f
C_x_PM_LS_LHEN_X1%8_c9 x_PM_LS_LHEN_X1%8_16 VSS 0.0162587f
C_x_PM_LS_LHEN_X1%8_c10 N_8_M5_g VSS 0.0706531f
C_x_PM_LS_LHEN_X1%8_c11 N_8_M14_g VSS 0.0404816f
C_x_PM_LS_LHEN_X1%8_c12 N_8_M2_g VSS 0.0341148f
R_x_PM_LS_LHEN_X1%8_r13 x_PM_LS_LHEN_X1%8_40 x_PM_LS_LHEN_X1%8_42 3.38
R_x_PM_LS_LHEN_X1%8_r14 x_PM_LS_LHEN_X1%8_32 x_PM_LS_LHEN_X1%8_40 25.0012
R_x_PM_LS_LHEN_X1%8_r15 x_PM_LS_LHEN_X1%8_30 x_PM_LS_LHEN_X1%8_32 3.16214
R_x_PM_LS_LHEN_X1%8_r16 x_PM_LS_LHEN_X1%8_26 x_PM_LS_LHEN_X1%8_35 0.266978
R_x_PM_LS_LHEN_X1%8_r17 x_PM_LS_LHEN_X1%8_26 N_8_M3_d 0.583571
R_x_PM_LS_LHEN_X1%8_r18 x_PM_LS_LHEN_X1%8_25 x_PM_LS_LHEN_X1%8_35 0.266978
R_x_PM_LS_LHEN_X1%8_r19 x_PM_LS_LHEN_X1%8_24 x_PM_LS_LHEN_X1%8_30 0.095
R_x_PM_LS_LHEN_X1%8_r20 x_PM_LS_LHEN_X1%8_24 x_PM_LS_LHEN_X1%8_25 1.87286
R_x_PM_LS_LHEN_X1%8_r21 x_PM_LS_LHEN_X1%8_22 x_PM_LS_LHEN_X1%8_30 0.19
R_x_PM_LS_LHEN_X1%8_r22 x_PM_LS_LHEN_X1%8_22 x_PM_LS_LHEN_X1%8_23 0.732857
R_x_PM_LS_LHEN_X1%8_r23 x_PM_LS_LHEN_X1%8_18 x_PM_LS_LHEN_X1%8_23 0.212317
R_x_PM_LS_LHEN_X1%8_r24 x_PM_LS_LHEN_X1%8_18 N_8_M11_s 1.37071
R_x_PM_LS_LHEN_X1%8_r25 x_PM_LS_LHEN_X1%8_17 x_PM_LS_LHEN_X1%8_35 0.0272847
R_x_PM_LS_LHEN_X1%8_r26 x_PM_LS_LHEN_X1%8_36 x_PM_LS_LHEN_X1%8_16 4.42
R_x_PM_LS_LHEN_X1%8_r27 x_PM_LS_LHEN_X1%8_15 x_PM_LS_LHEN_X1%8_17 0.572472
R_x_PM_LS_LHEN_X1%8_r28 x_PM_LS_LHEN_X1%8_15 x_PM_LS_LHEN_X1%8_16 25.0012
R_x_PM_LS_LHEN_X1%8_r29 x_PM_LS_LHEN_X1%8_9 x_PM_LS_LHEN_X1%8_42 1.95
R_x_PM_LS_LHEN_X1%8_r30 x_PM_LS_LHEN_X1%8_9 N_8_M5_g 79.56
R_x_PM_LS_LHEN_X1%8_r31 x_PM_LS_LHEN_X1%8_5 x_PM_LS_LHEN_X1%8_42 1.95
R_x_PM_LS_LHEN_X1%8_r32 x_PM_LS_LHEN_X1%8_5 N_8_M14_g 37.44
R_x_PM_LS_LHEN_X1%8_r33 x_PM_LS_LHEN_X1%8_1 x_PM_LS_LHEN_X1%8_36 1.95
R_x_PM_LS_LHEN_X1%8_r34 x_PM_LS_LHEN_X1%8_1 N_8_M2_g 26.13
C_x_PM_LS_LHEN_X1%ISOLN_c0 x_PM_LS_LHEN_X1%ISOLN_22 VSS 0.0451198f
C_x_PM_LS_LHEN_X1%ISOLN_c1 x_PM_LS_LHEN_X1%ISOLN_21 VSS 0.00530293f
C_x_PM_LS_LHEN_X1%ISOLN_c2 x_PM_LS_LHEN_X1%ISOLN_20 VSS 0.0282658f
C_x_PM_LS_LHEN_X1%ISOLN_c3 x_PM_LS_LHEN_X1%ISOLN_19 VSS 0.0104125f
C_x_PM_LS_LHEN_X1%ISOLN_c4 N_ISOLN_M4_g VSS 0.054906f
C_x_PM_LS_LHEN_X1%ISOLN_c5 N_ISOLN_M13_g VSS 0.0618516f
C_x_PM_LS_LHEN_X1%ISOLN_c6 N_ISOLN_M12_g VSS 0.0599111f
C_x_PM_LS_LHEN_X1%ISOLN_c7 x_PM_LS_LHEN_X1%ISOLN_6 VSS 0.00559264f
C_x_PM_LS_LHEN_X1%ISOLN_c8 x_PM_LS_LHEN_X1%ISOLN_5 VSS 0.0924516f
C_x_PM_LS_LHEN_X1%ISOLN_c9 N_ISOLN_M9_g VSS 0.032659f
R_x_PM_LS_LHEN_X1%ISOLN_r10 x_PM_LS_LHEN_X1%ISOLN_22 x_PM_LS_LHEN_X1%ISOLN_24 25.0012
R_x_PM_LS_LHEN_X1%ISOLN_r11 x_PM_LS_LHEN_X1%ISOLN_22 ISOLN 0.26037
R_x_PM_LS_LHEN_X1%ISOLN_r12 x_PM_LS_LHEN_X1%ISOLN_20 x_PM_LS_LHEN_X1%ISOLN_24 9.75
R_x_PM_LS_LHEN_X1%ISOLN_r13 x_PM_LS_LHEN_X1%ISOLN_20 x_PM_LS_LHEN_X1%ISOLN_21 0.422157
R_x_PM_LS_LHEN_X1%ISOLN_r14 x_PM_LS_LHEN_X1%ISOLN_19 x_PM_LS_LHEN_X1%ISOLN_24 16.25
R_x_PM_LS_LHEN_X1%ISOLN_r15 x_PM_LS_LHEN_X1%ISOLN_15 x_PM_LS_LHEN_X1%ISOLN_21 5.21812
R_x_PM_LS_LHEN_X1%ISOLN_r16 x_PM_LS_LHEN_X1%ISOLN_15 N_ISOLN_M4_g 56.16
R_x_PM_LS_LHEN_X1%ISOLN_r17 x_PM_LS_LHEN_X1%ISOLN_11 x_PM_LS_LHEN_X1%ISOLN_21 5.21812
R_x_PM_LS_LHEN_X1%ISOLN_r18 x_PM_LS_LHEN_X1%ISOLN_11 N_ISOLN_M13_g 58.5
R_x_PM_LS_LHEN_X1%ISOLN_r19 x_PM_LS_LHEN_X1%ISOLN_8 x_PM_LS_LHEN_X1%ISOLN_19 4.83753
R_x_PM_LS_LHEN_X1%ISOLN_r20 x_PM_LS_LHEN_X1%ISOLN_8 N_ISOLN_M12_g 58.5
R_x_PM_LS_LHEN_X1%ISOLN_r21 x_PM_LS_LHEN_X1%ISOLN_7 N_ISOLN_M12_g 26.52
R_x_PM_LS_LHEN_X1%ISOLN_r22 x_PM_LS_LHEN_X1%ISOLN_5 x_PM_LS_LHEN_X1%ISOLN_7 4.35808
R_x_PM_LS_LHEN_X1%ISOLN_r23 x_PM_LS_LHEN_X1%ISOLN_5 x_PM_LS_LHEN_X1%ISOLN_6 104.52
R_x_PM_LS_LHEN_X1%ISOLN_r24 x_PM_LS_LHEN_X1%ISOLN_1 x_PM_LS_LHEN_X1%ISOLN_6 4.35808
R_x_PM_LS_LHEN_X1%ISOLN_r25 x_PM_LS_LHEN_X1%ISOLN_1 N_ISOLN_M9_g 26.52
C_x_PM_LS_LHEN_X1%10_c0 x_PM_LS_LHEN_X1%10_28 VSS 0.013937f
C_x_PM_LS_LHEN_X1%10_c1 x_PM_LS_LHEN_X1%10_24 VSS 0.114652f
C_x_PM_LS_LHEN_X1%10_c2 x_PM_LS_LHEN_X1%10_20 VSS 0.00635666f
C_x_PM_LS_LHEN_X1%10_c3 x_PM_LS_LHEN_X1%10_19 VSS 0.0484281f
C_x_PM_LS_LHEN_X1%10_c4 N_10_M4_d VSS 0.0361188f
C_x_PM_LS_LHEN_X1%10_c5 x_PM_LS_LHEN_X1%10_14 VSS 0.0175541f
C_x_PM_LS_LHEN_X1%10_c6 x_PM_LS_LHEN_X1%10_13 VSS 0.0927782f
C_x_PM_LS_LHEN_X1%10_c7 x_PM_LS_LHEN_X1%10_12 VSS 0.0402081f
C_x_PM_LS_LHEN_X1%10_c8 N_10_M6_g VSS 0.0573836f
C_x_PM_LS_LHEN_X1%10_c9 N_10_M15_g VSS 0.0598877f
R_x_PM_LS_LHEN_X1%10_r10 x_PM_LS_LHEN_X1%10_26 x_PM_LS_LHEN_X1%10_28 5.46
R_x_PM_LS_LHEN_X1%10_r11 x_PM_LS_LHEN_X1%10_24 x_PM_LS_LHEN_X1%10_26 25.0012
R_x_PM_LS_LHEN_X1%10_r12 x_PM_LS_LHEN_X1%10_22 x_PM_LS_LHEN_X1%10_24 1.28929
R_x_PM_LS_LHEN_X1%10_r13 x_PM_LS_LHEN_X1%10_21 x_PM_LS_LHEN_X1%10_24 1.425
R_x_PM_LS_LHEN_X1%10_r14 x_PM_LS_LHEN_X1%10_19 x_PM_LS_LHEN_X1%10_22 0.212317
R_x_PM_LS_LHEN_X1%10_r15 x_PM_LS_LHEN_X1%10_19 x_PM_LS_LHEN_X1%10_20 0.868571
R_x_PM_LS_LHEN_X1%10_r16 x_PM_LS_LHEN_X1%10_15 x_PM_LS_LHEN_X1%10_20 0.212317
R_x_PM_LS_LHEN_X1%10_r17 x_PM_LS_LHEN_X1%10_15 N_10_M4_d 0.637857
R_x_PM_LS_LHEN_X1%10_r18 x_PM_LS_LHEN_X1%10_13 x_PM_LS_LHEN_X1%10_21 0.212317
R_x_PM_LS_LHEN_X1%10_r19 x_PM_LS_LHEN_X1%10_13 x_PM_LS_LHEN_X1%10_14 1.87286
R_x_PM_LS_LHEN_X1%10_r20 x_PM_LS_LHEN_X1%10_12 x_PM_LS_LHEN_X1%10_14 0.212317
R_x_PM_LS_LHEN_X1%10_r21 N_10_M13_s x_PM_LS_LHEN_X1%10_12 0.570339
R_x_PM_LS_LHEN_X1%10_r22 x_PM_LS_LHEN_X1%10_5 x_PM_LS_LHEN_X1%10_28 1.95
R_x_PM_LS_LHEN_X1%10_r23 x_PM_LS_LHEN_X1%10_5 N_10_M6_g 54.6
R_x_PM_LS_LHEN_X1%10_r24 x_PM_LS_LHEN_X1%10_1 x_PM_LS_LHEN_X1%10_28 1.95
R_x_PM_LS_LHEN_X1%10_r25 x_PM_LS_LHEN_X1%10_1 N_10_M15_g 66.3
C_x_PM_LS_LHEN_X1%Z_c0 N_Z_M15_d VSS 0.190614f
R_x_PM_LS_LHEN_X1%Z_r1 Z N_Z_M6_d 2.49533
R_x_PM_LS_LHEN_X1%Z_r2 N_Z_M15_d Z 2.03933
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_LHEN_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LHEN_X2 VDD VSS A VDDL ISOLN Z
*.PININFO VDD:P VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M9 N_VDDL_M0_d N_A_M0_g N_4_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M10 N_6_M1_d N_4_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M11 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M12 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M13 N_10_M4_d N_ISOLN_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M14 N_VDD_M5_d N_8_M5_g N_10_M4_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M15 N_Z_M6_d N_10_M6_g N_VDD_M5_d N_VDD_M2_b PMOS_VTL L=5e-08 W=2.7e-07
M_M0 N_VSS_M7_d N_A_M7_g N_4_M7_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M8_d N_4_M8_g N_VSS_M7_d N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M2 12 N_ISOLN_M9_g N_VSS_M9_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_7_M10_d N_6_M10_g 12 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M4 13 N_4_M11_g N_8_M11_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M5 N_VSS_M12_d N_ISOLN_M12_g 13 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M6 14 N_ISOLN_M13_g N_10_M13_s N_VSS_M7_b NMOS_VTL L=5e-08 W=1.3e-07
M_M7 N_VSS_M14_d N_8_M14_g 14 N_VSS_M7_b NMOS_VTL L=5e-08 W=1.3e-07
M_M8 N_Z_M15_d N_10_M15_g N_VSS_M14_d N_VSS_M7_b NMOS_VTL L=5e-08 W=1.8e-07
C_x_PM_LS_LHEN_X2%VDD_c0 x_PM_LS_LHEN_X2%VDD_49 VSS 0.0225764f
C_x_PM_LS_LHEN_X2%VDD_c1 x_PM_LS_LHEN_X2%VDD_46 VSS 0.00566898f
C_x_PM_LS_LHEN_X2%VDD_c2 x_PM_LS_LHEN_X2%VDD_45 VSS 0.00296767f
C_x_PM_LS_LHEN_X2%VDD_c3 x_PM_LS_LHEN_X2%VDD_44 VSS 0.00292673f
C_x_PM_LS_LHEN_X2%VDD_c4 x_PM_LS_LHEN_X2%VDD_43 VSS 0.0108319f
C_x_PM_LS_LHEN_X2%VDD_c5 x_PM_LS_LHEN_X2%VDD_42 VSS 0.2334f
C_x_PM_LS_LHEN_X2%VDD_c6 x_PM_LS_LHEN_X2%VDD_33 VSS 0.261448f
C_x_PM_LS_LHEN_X2%VDD_c7 x_PM_LS_LHEN_X2%VDD_30 VSS 0.0326315f
C_x_PM_LS_LHEN_X2%VDD_c8 x_PM_LS_LHEN_X2%VDD_27 VSS 0.0206865f
C_x_PM_LS_LHEN_X2%VDD_c9 N_VDD_M4_s VSS 0.028069f
C_x_PM_LS_LHEN_X2%VDD_c10 x_PM_LS_LHEN_X2%VDD_21 VSS 0.0394772f
C_x_PM_LS_LHEN_X2%VDD_c11 N_VDD_M2_d VSS 0.0291285f
C_x_PM_LS_LHEN_X2%VDD_c12 x_PM_LS_LHEN_X2%VDD_15 VSS 0.122964f
C_x_PM_LS_LHEN_X2%VDD_c13 x_PM_LS_LHEN_X2%VDD_14 VSS 0.0192462f
C_x_PM_LS_LHEN_X2%VDD_c14 x_PM_LS_LHEN_X2%VDD_10 VSS 0.706493f
R_x_PM_LS_LHEN_X2%VDD_r15 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_49 0.13879
R_x_PM_LS_LHEN_X2%VDD_r16 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_43 0.138595
R_x_PM_LS_LHEN_X2%VDD_r17 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_42 0.138985
R_x_PM_LS_LHEN_X2%VDD_r18 N_VDD_M2_b x_PM_LS_LHEN_X2%VDD_33 0.13879
R_x_PM_LS_LHEN_X2%VDD_r19 x_PM_LS_LHEN_X2%VDD_33 VDD 3.84471
R_x_PM_LS_LHEN_X2%VDD_r20 x_PM_LS_LHEN_X2%VDD_32 x_PM_LS_LHEN_X2%VDD_46 0.132285
R_x_PM_LS_LHEN_X2%VDD_r21 x_PM_LS_LHEN_X2%VDD_49 x_PM_LS_LHEN_X2%VDD_32 0.57
R_x_PM_LS_LHEN_X2%VDD_r22 x_PM_LS_LHEN_X2%VDD_30 x_PM_LS_LHEN_X2%VDD_46 0.0680382
R_x_PM_LS_LHEN_X2%VDD_r23 N_VDD_M5_d x_PM_LS_LHEN_X2%VDD_30 0.375435
R_x_PM_LS_LHEN_X2%VDD_r24 x_PM_LS_LHEN_X2%VDD_28 x_PM_LS_LHEN_X2%VDD_45 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r25 x_PM_LS_LHEN_X2%VDD_27 x_PM_LS_LHEN_X2%VDD_46 0.132285
R_x_PM_LS_LHEN_X2%VDD_r26 x_PM_LS_LHEN_X2%VDD_27 x_PM_LS_LHEN_X2%VDD_28 0.625882
R_x_PM_LS_LHEN_X2%VDD_r27 x_PM_LS_LHEN_X2%VDD_23 x_PM_LS_LHEN_X2%VDD_45 0.145286
R_x_PM_LS_LHEN_X2%VDD_r28 x_PM_LS_LHEN_X2%VDD_23 N_VDD_M4_s 1.07214
R_x_PM_LS_LHEN_X2%VDD_r29 x_PM_LS_LHEN_X2%VDD_22 x_PM_LS_LHEN_X2%VDD_44 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r30 x_PM_LS_LHEN_X2%VDD_21 x_PM_LS_LHEN_X2%VDD_45 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r31 x_PM_LS_LHEN_X2%VDD_21 x_PM_LS_LHEN_X2%VDD_22 1.02824
R_x_PM_LS_LHEN_X2%VDD_r32 x_PM_LS_LHEN_X2%VDD_17 x_PM_LS_LHEN_X2%VDD_44 0.145286
R_x_PM_LS_LHEN_X2%VDD_r33 x_PM_LS_LHEN_X2%VDD_17 N_VDD_M2_d 0.502143
R_x_PM_LS_LHEN_X2%VDD_r34 x_PM_LS_LHEN_X2%VDD_15 x_PM_LS_LHEN_X2%VDD_44 0.0731438
R_x_PM_LS_LHEN_X2%VDD_r35 x_PM_LS_LHEN_X2%VDD_15 x_PM_LS_LHEN_X2%VDD_43 3.30824
R_x_PM_LS_LHEN_X2%VDD_r36 x_PM_LS_LHEN_X2%VDD_14 N_VDD_M2_b 0.140282
R_x_PM_LS_LHEN_X2%VDD_r37 x_PM_LS_LHEN_X2%VDD_42 x_PM_LS_LHEN_X2%VDD_14 7.68941
R_x_PM_LS_LHEN_X2%VDD_r38 x_PM_LS_LHEN_X2%VDD_10 VDD 11.0647
C_x_PM_LS_LHEN_X2%VSS_c0 x_PM_LS_LHEN_X2%VSS_57 VSS 0.00562691f
C_x_PM_LS_LHEN_X2%VSS_c1 x_PM_LS_LHEN_X2%VSS_56 VSS 0.00281563f
C_x_PM_LS_LHEN_X2%VSS_c2 x_PM_LS_LHEN_X2%VSS_55 VSS 0.00281385f
C_x_PM_LS_LHEN_X2%VSS_c3 x_PM_LS_LHEN_X2%VSS_54 VSS 0.00293741f
C_x_PM_LS_LHEN_X2%VSS_c4 x_PM_LS_LHEN_X2%VSS_52 VSS 0.2334f
C_x_PM_LS_LHEN_X2%VSS_c5 N_VSS_M7_b VSS 0.261559f
C_x_PM_LS_LHEN_X2%VSS_c6 x_PM_LS_LHEN_X2%VSS_42 VSS 0.0220233f
C_x_PM_LS_LHEN_X2%VSS_c7 N_VSS_M14_d VSS 0.0252241f
C_x_PM_LS_LHEN_X2%VSS_c8 x_PM_LS_LHEN_X2%VSS_36 VSS 0.0382058f
C_x_PM_LS_LHEN_X2%VSS_c9 N_VSS_M12_d VSS 0.0382663f
C_x_PM_LS_LHEN_X2%VSS_c10 x_PM_LS_LHEN_X2%VSS_28 VSS 0.0908707f
C_x_PM_LS_LHEN_X2%VSS_c11 N_VSS_M9_s VSS 0.0459145f
C_x_PM_LS_LHEN_X2%VSS_c12 x_PM_LS_LHEN_X2%VSS_22 VSS 0.0357401f
C_x_PM_LS_LHEN_X2%VSS_c13 N_VSS_M7_d VSS 0.0409801f
C_x_PM_LS_LHEN_X2%VSS_c14 x_PM_LS_LHEN_X2%VSS_17 VSS 0.0106021f
C_x_PM_LS_LHEN_X2%VSS_c15 x_PM_LS_LHEN_X2%VSS_16 VSS 0.0548707f
C_x_PM_LS_LHEN_X2%VSS_c16 x_PM_LS_LHEN_X2%VSS_13 VSS 0.706493f
C_x_PM_LS_LHEN_X2%VSS_c17 x_PM_LS_LHEN_X2%VSS_12 VSS 0.0192462f
R_x_PM_LS_LHEN_X2%VSS_r18 N_VSS_M7_b x_PM_LS_LHEN_X2%VSS_52 0.138985
R_x_PM_LS_LHEN_X2%VSS_r19 x_PM_LS_LHEN_X2%VSS_43 x_PM_LS_LHEN_X2%VSS_57 0.132285
R_x_PM_LS_LHEN_X2%VSS_r20 N_VSS_M7_b x_PM_LS_LHEN_X2%VSS_42 0.13879
R_x_PM_LS_LHEN_X2%VSS_r21 x_PM_LS_LHEN_X2%VSS_42 x_PM_LS_LHEN_X2%VSS_43 0.57
R_x_PM_LS_LHEN_X2%VSS_r22 x_PM_LS_LHEN_X2%VSS_38 x_PM_LS_LHEN_X2%VSS_57 0.0680382
R_x_PM_LS_LHEN_X2%VSS_r23 x_PM_LS_LHEN_X2%VSS_38 N_VSS_M14_d 0.302593
R_x_PM_LS_LHEN_X2%VSS_r24 x_PM_LS_LHEN_X2%VSS_37 x_PM_LS_LHEN_X2%VSS_56 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r25 x_PM_LS_LHEN_X2%VSS_36 x_PM_LS_LHEN_X2%VSS_57 0.132285
R_x_PM_LS_LHEN_X2%VSS_r26 x_PM_LS_LHEN_X2%VSS_36 x_PM_LS_LHEN_X2%VSS_37 0.972353
R_x_PM_LS_LHEN_X2%VSS_r27 x_PM_LS_LHEN_X2%VSS_32 x_PM_LS_LHEN_X2%VSS_56 0.145286
R_x_PM_LS_LHEN_X2%VSS_r28 x_PM_LS_LHEN_X2%VSS_32 N_VSS_M12_d 1.01786
R_x_PM_LS_LHEN_X2%VSS_r29 x_PM_LS_LHEN_X2%VSS_29 x_PM_LS_LHEN_X2%VSS_55 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r30 x_PM_LS_LHEN_X2%VSS_29 VSS 0.782353
R_x_PM_LS_LHEN_X2%VSS_r31 x_PM_LS_LHEN_X2%VSS_28 x_PM_LS_LHEN_X2%VSS_56 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r32 x_PM_LS_LHEN_X2%VSS_28 VSS 1.07294
R_x_PM_LS_LHEN_X2%VSS_r33 x_PM_LS_LHEN_X2%VSS_24 x_PM_LS_LHEN_X2%VSS_55 0.145286
R_x_PM_LS_LHEN_X2%VSS_r34 x_PM_LS_LHEN_X2%VSS_24 N_VSS_M9_s 0.990714
R_x_PM_LS_LHEN_X2%VSS_r35 x_PM_LS_LHEN_X2%VSS_23 x_PM_LS_LHEN_X2%VSS_54 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r36 x_PM_LS_LHEN_X2%VSS_22 x_PM_LS_LHEN_X2%VSS_55 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r37 x_PM_LS_LHEN_X2%VSS_22 x_PM_LS_LHEN_X2%VSS_23 0.681765
R_x_PM_LS_LHEN_X2%VSS_r38 x_PM_LS_LHEN_X2%VSS_18 x_PM_LS_LHEN_X2%VSS_54 0.145286
R_x_PM_LS_LHEN_X2%VSS_r39 x_PM_LS_LHEN_X2%VSS_18 N_VSS_M7_d 0.637857
R_x_PM_LS_LHEN_X2%VSS_r40 N_VSS_M7_b x_PM_LS_LHEN_X2%VSS_17 0.138595
R_x_PM_LS_LHEN_X2%VSS_r41 x_PM_LS_LHEN_X2%VSS_16 x_PM_LS_LHEN_X2%VSS_54 0.0731438
R_x_PM_LS_LHEN_X2%VSS_r42 x_PM_LS_LHEN_X2%VSS_16 x_PM_LS_LHEN_X2%VSS_17 1.29647
R_x_PM_LS_LHEN_X2%VSS_r43 x_PM_LS_LHEN_X2%VSS_13 VSS 11.0647
R_x_PM_LS_LHEN_X2%VSS_r44 x_PM_LS_LHEN_X2%VSS_12 N_VSS_M7_b 0.140282
R_x_PM_LS_LHEN_X2%VSS_r45 x_PM_LS_LHEN_X2%VSS_52 x_PM_LS_LHEN_X2%VSS_12 7.68941
C_x_PM_LS_LHEN_X2%A_c0 x_PM_LS_LHEN_X2%A_21 VSS 0.0117047f
C_x_PM_LS_LHEN_X2%A_c1 x_PM_LS_LHEN_X2%A_14 VSS 0.0807116f
C_x_PM_LS_LHEN_X2%A_c2 x_PM_LS_LHEN_X2%A_13 VSS 0.00484899f
C_x_PM_LS_LHEN_X2%A_c3 A VSS 0.0221116f
C_x_PM_LS_LHEN_X2%A_c4 N_A_M0_g VSS 0.0377071f
C_x_PM_LS_LHEN_X2%A_c5 N_A_M7_g VSS 0.0431427f
R_x_PM_LS_LHEN_X2%A_r6 x_PM_LS_LHEN_X2%A_16 x_PM_LS_LHEN_X2%A_21 2.86
R_x_PM_LS_LHEN_X2%A_r7 x_PM_LS_LHEN_X2%A_18 x_PM_LS_LHEN_X2%A_16 2.34
R_x_PM_LS_LHEN_X2%A_r8 x_PM_LS_LHEN_X2%A_14 x_PM_LS_LHEN_X2%A_16 25.0012
R_x_PM_LS_LHEN_X2%A_r9 x_PM_LS_LHEN_X2%A_13 x_PM_LS_LHEN_X2%A_14 0.963571
R_x_PM_LS_LHEN_X2%A_r10 x_PM_LS_LHEN_X2%A_9 x_PM_LS_LHEN_X2%A_13 0.212317
R_x_PM_LS_LHEN_X2%A_r11 x_PM_LS_LHEN_X2%A_9 A 0.488571
R_x_PM_LS_LHEN_X2%A_r12 x_PM_LS_LHEN_X2%A_5 x_PM_LS_LHEN_X2%A_21 1.95
R_x_PM_LS_LHEN_X2%A_r13 x_PM_LS_LHEN_X2%A_5 N_A_M0_g 31.98
R_x_PM_LS_LHEN_X2%A_r14 x_PM_LS_LHEN_X2%A_1 x_PM_LS_LHEN_X2%A_18 1.95
R_x_PM_LS_LHEN_X2%A_r15 x_PM_LS_LHEN_X2%A_1 N_A_M7_g 39.78
C_x_PM_LS_LHEN_X2%4_c0 x_PM_LS_LHEN_X2%4_36 VSS 0.0597866f
C_x_PM_LS_LHEN_X2%4_c1 x_PM_LS_LHEN_X2%4_32 VSS 0.0279334f
C_x_PM_LS_LHEN_X2%4_c2 x_PM_LS_LHEN_X2%4_31 VSS 0.0658776f
C_x_PM_LS_LHEN_X2%4_c3 x_PM_LS_LHEN_X2%4_30 VSS 0.0175113f
C_x_PM_LS_LHEN_X2%4_c4 x_PM_LS_LHEN_X2%4_29 VSS 0.0645231f
C_x_PM_LS_LHEN_X2%4_c5 N_4_M0_s VSS 0.0208149f
C_x_PM_LS_LHEN_X2%4_c6 N_4_M7_s VSS 0.0337191f
C_x_PM_LS_LHEN_X2%4_c7 N_4_M11_g VSS 0.053781f
C_x_PM_LS_LHEN_X2%4_c8 x_PM_LS_LHEN_X2%4_14 VSS 0.00856457f
C_x_PM_LS_LHEN_X2%4_c9 x_PM_LS_LHEN_X2%4_13 VSS 0.0716788f
C_x_PM_LS_LHEN_X2%4_c10 x_PM_LS_LHEN_X2%4_12 VSS 0.0113433f
C_x_PM_LS_LHEN_X2%4_c11 x_PM_LS_LHEN_X2%4_10 VSS 0.00890825f
C_x_PM_LS_LHEN_X2%4_c12 x_PM_LS_LHEN_X2%4_9 VSS 0.0335497f
C_x_PM_LS_LHEN_X2%4_c13 N_4_M1_g VSS 0.0324613f
C_x_PM_LS_LHEN_X2%4_c14 N_4_M8_g VSS 0.0352024f
R_x_PM_LS_LHEN_X2%4_r15 x_PM_LS_LHEN_X2%4_40 x_PM_LS_LHEN_X2%4_41 4.42
R_x_PM_LS_LHEN_X2%4_r16 x_PM_LS_LHEN_X2%4_38 x_PM_LS_LHEN_X2%4_40 0.78
R_x_PM_LS_LHEN_X2%4_r17 x_PM_LS_LHEN_X2%4_36 x_PM_LS_LHEN_X2%4_40 25.0012
R_x_PM_LS_LHEN_X2%4_r18 x_PM_LS_LHEN_X2%4_34 x_PM_LS_LHEN_X2%4_36 0.637857
R_x_PM_LS_LHEN_X2%4_r19 x_PM_LS_LHEN_X2%4_33 x_PM_LS_LHEN_X2%4_36 0.447857
R_x_PM_LS_LHEN_X2%4_r20 x_PM_LS_LHEN_X2%4_31 x_PM_LS_LHEN_X2%4_34 0.212317
R_x_PM_LS_LHEN_X2%4_r21 x_PM_LS_LHEN_X2%4_31 x_PM_LS_LHEN_X2%4_32 0.922857
R_x_PM_LS_LHEN_X2%4_r22 x_PM_LS_LHEN_X2%4_29 x_PM_LS_LHEN_X2%4_33 0.212317
R_x_PM_LS_LHEN_X2%4_r23 x_PM_LS_LHEN_X2%4_29 x_PM_LS_LHEN_X2%4_30 1.19429
R_x_PM_LS_LHEN_X2%4_r24 x_PM_LS_LHEN_X2%4_25 x_PM_LS_LHEN_X2%4_32 0.212317
R_x_PM_LS_LHEN_X2%4_r25 x_PM_LS_LHEN_X2%4_25 N_4_M0_s 0.285
R_x_PM_LS_LHEN_X2%4_r26 x_PM_LS_LHEN_X2%4_21 x_PM_LS_LHEN_X2%4_30 0.212317
R_x_PM_LS_LHEN_X2%4_r27 x_PM_LS_LHEN_X2%4_21 N_4_M7_s 0.637857
R_x_PM_LS_LHEN_X2%4_r28 x_PM_LS_LHEN_X2%4_15 N_4_M11_g 52.26
R_x_PM_LS_LHEN_X2%4_r29 x_PM_LS_LHEN_X2%4_13 x_PM_LS_LHEN_X2%4_15 4.58872
R_x_PM_LS_LHEN_X2%4_r30 x_PM_LS_LHEN_X2%4_13 x_PM_LS_LHEN_X2%4_14 53.04
R_x_PM_LS_LHEN_X2%4_r31 x_PM_LS_LHEN_X2%4_12 x_PM_LS_LHEN_X2%4_14 4.35808
R_x_PM_LS_LHEN_X2%4_r32 x_PM_LS_LHEN_X2%4_11 x_PM_LS_LHEN_X2%4_12 8.84
R_x_PM_LS_LHEN_X2%4_r33 x_PM_LS_LHEN_X2%4_10 x_PM_LS_LHEN_X2%4_41 2.6
R_x_PM_LS_LHEN_X2%4_r34 x_PM_LS_LHEN_X2%4_9 x_PM_LS_LHEN_X2%4_11 4.35808
R_x_PM_LS_LHEN_X2%4_r35 x_PM_LS_LHEN_X2%4_9 x_PM_LS_LHEN_X2%4_10 22.36
R_x_PM_LS_LHEN_X2%4_r36 x_PM_LS_LHEN_X2%4_5 x_PM_LS_LHEN_X2%4_41 1.95
R_x_PM_LS_LHEN_X2%4_r37 x_PM_LS_LHEN_X2%4_5 N_4_M1_g 34.32
R_x_PM_LS_LHEN_X2%4_r38 x_PM_LS_LHEN_X2%4_1 x_PM_LS_LHEN_X2%4_38 1.95
R_x_PM_LS_LHEN_X2%4_r39 x_PM_LS_LHEN_X2%4_1 N_4_M8_g 37.44
C_x_PM_LS_LHEN_X2%VDDL_c0 VDDL VSS 0.0627381f
C_x_PM_LS_LHEN_X2%VDDL_c1 x_PM_LS_LHEN_X2%VDDL_6 VSS 0.0577157f
R_x_PM_LS_LHEN_X2%VDDL_r2 N_VDDL_M0_b VDDL 0.18525
R_x_PM_LS_LHEN_X2%VDDL_r3 x_PM_LS_LHEN_X2%VDDL_7 N_VDDL_M0_b 0.0095
R_x_PM_LS_LHEN_X2%VDDL_r4 x_PM_LS_LHEN_X2%VDDL_6 x_PM_LS_LHEN_X2%VDDL_7 0.095
R_x_PM_LS_LHEN_X2%VDDL_r5 N_VDDL_M0_d x_PM_LS_LHEN_X2%VDDL_6 0.347287
C_x_PM_LS_LHEN_X2%6_c0 x_PM_LS_LHEN_X2%6_28 VSS 0.0130595f
C_x_PM_LS_LHEN_X2%6_c1 x_PM_LS_LHEN_X2%6_25 VSS 0.0168246f
C_x_PM_LS_LHEN_X2%6_c2 x_PM_LS_LHEN_X2%6_23 VSS 0.049992f
C_x_PM_LS_LHEN_X2%6_c3 x_PM_LS_LHEN_X2%6_17 VSS 0.0334979f
C_x_PM_LS_LHEN_X2%6_c4 x_PM_LS_LHEN_X2%6_13 VSS 0.046439f
C_x_PM_LS_LHEN_X2%6_c5 N_6_M1_d VSS 0.0322045f
C_x_PM_LS_LHEN_X2%6_c6 x_PM_LS_LHEN_X2%6_8 VSS 0.0615079f
C_x_PM_LS_LHEN_X2%6_c7 N_6_M10_g VSS 0.0262886f
R_x_PM_LS_LHEN_X2%6_r8 x_PM_LS_LHEN_X2%6_26 x_PM_LS_LHEN_X2%6_28 3.9
R_x_PM_LS_LHEN_X2%6_r9 N_6_M8_d x_PM_LS_LHEN_X2%6_23 0.257857
R_x_PM_LS_LHEN_X2%6_r10 x_PM_LS_LHEN_X2%6_17 x_PM_LS_LHEN_X2%6_26 25.0012
R_x_PM_LS_LHEN_X2%6_r11 x_PM_LS_LHEN_X2%6_15 x_PM_LS_LHEN_X2%6_17 0.583571
R_x_PM_LS_LHEN_X2%6_r12 x_PM_LS_LHEN_X2%6_14 x_PM_LS_LHEN_X2%6_25 0.0418175
R_x_PM_LS_LHEN_X2%6_r13 x_PM_LS_LHEN_X2%6_13 x_PM_LS_LHEN_X2%6_15 0.212317
R_x_PM_LS_LHEN_X2%6_r14 x_PM_LS_LHEN_X2%6_13 x_PM_LS_LHEN_X2%6_14 1.65571
R_x_PM_LS_LHEN_X2%6_r15 x_PM_LS_LHEN_X2%6_9 x_PM_LS_LHEN_X2%6_25 0.160909
R_x_PM_LS_LHEN_X2%6_r16 x_PM_LS_LHEN_X2%6_9 N_6_M1_d 0.637857
R_x_PM_LS_LHEN_X2%6_r17 x_PM_LS_LHEN_X2%6_8 x_PM_LS_LHEN_X2%6_25 0.160909
R_x_PM_LS_LHEN_X2%6_r18 x_PM_LS_LHEN_X2%6_7 x_PM_LS_LHEN_X2%6_23 0.095
R_x_PM_LS_LHEN_X2%6_r19 x_PM_LS_LHEN_X2%6_7 x_PM_LS_LHEN_X2%6_8 1.62857
R_x_PM_LS_LHEN_X2%6_r20 x_PM_LS_LHEN_X2%6_1 x_PM_LS_LHEN_X2%6_28 1.95
R_x_PM_LS_LHEN_X2%6_r21 x_PM_LS_LHEN_X2%6_1 N_6_M10_g 18.72
C_x_PM_LS_LHEN_X2%7_c0 x_PM_LS_LHEN_X2%7_23 VSS 0.0180574f
C_x_PM_LS_LHEN_X2%7_c1 x_PM_LS_LHEN_X2%7_20 VSS 0.00663771f
C_x_PM_LS_LHEN_X2%7_c2 x_PM_LS_LHEN_X2%7_16 VSS 0.047715f
C_x_PM_LS_LHEN_X2%7_c3 N_7_M2_s VSS 0.0588287f
C_x_PM_LS_LHEN_X2%7_c4 N_7_M10_d VSS 0.12033f
C_x_PM_LS_LHEN_X2%7_c5 N_7_M3_g VSS 0.0547966f
R_x_PM_LS_LHEN_X2%7_r6 x_PM_LS_LHEN_X2%7_18 x_PM_LS_LHEN_X2%7_23 5.98
R_x_PM_LS_LHEN_X2%7_r7 x_PM_LS_LHEN_X2%7_16 x_PM_LS_LHEN_X2%7_18 25.0012
R_x_PM_LS_LHEN_X2%7_r8 x_PM_LS_LHEN_X2%7_15 x_PM_LS_LHEN_X2%7_20 0.0418175
R_x_PM_LS_LHEN_X2%7_r9 x_PM_LS_LHEN_X2%7_15 x_PM_LS_LHEN_X2%7_16 0.827857
R_x_PM_LS_LHEN_X2%7_r10 x_PM_LS_LHEN_X2%7_11 x_PM_LS_LHEN_X2%7_20 0.160909
R_x_PM_LS_LHEN_X2%7_r11 x_PM_LS_LHEN_X2%7_7 x_PM_LS_LHEN_X2%7_20 0.160909
R_x_PM_LS_LHEN_X2%7_r12 x_PM_LS_LHEN_X2%7_7 N_7_M2_s 1.75071
R_x_PM_LS_LHEN_X2%7_r13 x_PM_LS_LHEN_X2%7_11 N_7_M10_d 2.67357
R_x_PM_LS_LHEN_X2%7_r14 x_PM_LS_LHEN_X2%7_1 x_PM_LS_LHEN_X2%7_23 1.95
R_x_PM_LS_LHEN_X2%7_r15 x_PM_LS_LHEN_X2%7_1 N_7_M3_g 54.99
C_x_PM_LS_LHEN_X2%8_c0 x_PM_LS_LHEN_X2%8_42 VSS 0.0100379f
C_x_PM_LS_LHEN_X2%8_c1 x_PM_LS_LHEN_X2%8_35 VSS 0.00585733f
C_x_PM_LS_LHEN_X2%8_c2 x_PM_LS_LHEN_X2%8_32 VSS 0.114098f
C_x_PM_LS_LHEN_X2%8_c3 N_8_M3_d VSS 0.030928f
C_x_PM_LS_LHEN_X2%8_c4 x_PM_LS_LHEN_X2%8_25 VSS 0.0362755f
C_x_PM_LS_LHEN_X2%8_c5 x_PM_LS_LHEN_X2%8_23 VSS 0.0193094f
C_x_PM_LS_LHEN_X2%8_c6 x_PM_LS_LHEN_X2%8_22 VSS 0.0121432f
C_x_PM_LS_LHEN_X2%8_c7 N_8_M11_s VSS 0.0590963f
C_x_PM_LS_LHEN_X2%8_c8 x_PM_LS_LHEN_X2%8_17 VSS 0.0789359f
C_x_PM_LS_LHEN_X2%8_c9 x_PM_LS_LHEN_X2%8_16 VSS 0.016132f
C_x_PM_LS_LHEN_X2%8_c10 N_8_M5_g VSS 0.069943f
C_x_PM_LS_LHEN_X2%8_c11 N_8_M14_g VSS 0.0465465f
C_x_PM_LS_LHEN_X2%8_c12 N_8_M2_g VSS 0.0335687f
R_x_PM_LS_LHEN_X2%8_r13 x_PM_LS_LHEN_X2%8_40 x_PM_LS_LHEN_X2%8_42 2.86
R_x_PM_LS_LHEN_X2%8_r14 x_PM_LS_LHEN_X2%8_32 x_PM_LS_LHEN_X2%8_40 25.0012
R_x_PM_LS_LHEN_X2%8_r15 x_PM_LS_LHEN_X2%8_30 x_PM_LS_LHEN_X2%8_32 3.135
R_x_PM_LS_LHEN_X2%8_r16 x_PM_LS_LHEN_X2%8_26 x_PM_LS_LHEN_X2%8_35 0.266978
R_x_PM_LS_LHEN_X2%8_r17 x_PM_LS_LHEN_X2%8_26 N_8_M3_d 0.583571
R_x_PM_LS_LHEN_X2%8_r18 x_PM_LS_LHEN_X2%8_25 x_PM_LS_LHEN_X2%8_35 0.266978
R_x_PM_LS_LHEN_X2%8_r19 x_PM_LS_LHEN_X2%8_24 x_PM_LS_LHEN_X2%8_30 0.095
R_x_PM_LS_LHEN_X2%8_r20 x_PM_LS_LHEN_X2%8_24 x_PM_LS_LHEN_X2%8_25 1.81857
R_x_PM_LS_LHEN_X2%8_r21 x_PM_LS_LHEN_X2%8_22 x_PM_LS_LHEN_X2%8_30 0.19
R_x_PM_LS_LHEN_X2%8_r22 x_PM_LS_LHEN_X2%8_22 x_PM_LS_LHEN_X2%8_23 0.732857
R_x_PM_LS_LHEN_X2%8_r23 x_PM_LS_LHEN_X2%8_18 x_PM_LS_LHEN_X2%8_23 0.212317
R_x_PM_LS_LHEN_X2%8_r24 x_PM_LS_LHEN_X2%8_18 N_8_M11_s 1.28929
R_x_PM_LS_LHEN_X2%8_r25 x_PM_LS_LHEN_X2%8_17 x_PM_LS_LHEN_X2%8_35 0.0272847
R_x_PM_LS_LHEN_X2%8_r26 x_PM_LS_LHEN_X2%8_36 x_PM_LS_LHEN_X2%8_16 4.42
R_x_PM_LS_LHEN_X2%8_r27 x_PM_LS_LHEN_X2%8_15 x_PM_LS_LHEN_X2%8_17 0.572472
R_x_PM_LS_LHEN_X2%8_r28 x_PM_LS_LHEN_X2%8_15 x_PM_LS_LHEN_X2%8_16 25.0012
R_x_PM_LS_LHEN_X2%8_r29 x_PM_LS_LHEN_X2%8_9 x_PM_LS_LHEN_X2%8_42 1.95
R_x_PM_LS_LHEN_X2%8_r30 x_PM_LS_LHEN_X2%8_9 N_8_M5_g 84.63
R_x_PM_LS_LHEN_X2%8_r31 x_PM_LS_LHEN_X2%8_5 x_PM_LS_LHEN_X2%8_42 1.95
R_x_PM_LS_LHEN_X2%8_r32 x_PM_LS_LHEN_X2%8_5 N_8_M14_g 47.58
R_x_PM_LS_LHEN_X2%8_r33 x_PM_LS_LHEN_X2%8_1 x_PM_LS_LHEN_X2%8_36 1.95
R_x_PM_LS_LHEN_X2%8_r34 x_PM_LS_LHEN_X2%8_1 N_8_M2_g 26.13
C_x_PM_LS_LHEN_X2%ISOLN_c0 ISOLN VSS 0.0327273f
C_x_PM_LS_LHEN_X2%ISOLN_c1 x_PM_LS_LHEN_X2%ISOLN_21 VSS 0.00441569f
C_x_PM_LS_LHEN_X2%ISOLN_c2 x_PM_LS_LHEN_X2%ISOLN_20 VSS 0.0243122f
C_x_PM_LS_LHEN_X2%ISOLN_c3 x_PM_LS_LHEN_X2%ISOLN_19 VSS 0.00894501f
C_x_PM_LS_LHEN_X2%ISOLN_c4 N_ISOLN_M4_g VSS 0.0520907f
C_x_PM_LS_LHEN_X2%ISOLN_c5 N_ISOLN_M13_g VSS 0.072415f
C_x_PM_LS_LHEN_X2%ISOLN_c6 N_ISOLN_M12_g VSS 0.0646441f
C_x_PM_LS_LHEN_X2%ISOLN_c7 x_PM_LS_LHEN_X2%ISOLN_6 VSS 0.0058849f
C_x_PM_LS_LHEN_X2%ISOLN_c8 x_PM_LS_LHEN_X2%ISOLN_5 VSS 0.0912043f
C_x_PM_LS_LHEN_X2%ISOLN_c9 N_ISOLN_M9_g VSS 0.0330452f
R_x_PM_LS_LHEN_X2%ISOLN_r10 x_PM_LS_LHEN_X2%ISOLN_22 x_PM_LS_LHEN_X2%ISOLN_24 25.0012
R_x_PM_LS_LHEN_X2%ISOLN_r11 x_PM_LS_LHEN_X2%ISOLN_22 ISOLN 0.183214
R_x_PM_LS_LHEN_X2%ISOLN_r12 x_PM_LS_LHEN_X2%ISOLN_20 x_PM_LS_LHEN_X2%ISOLN_24 14.82
R_x_PM_LS_LHEN_X2%ISOLN_r13 x_PM_LS_LHEN_X2%ISOLN_20 x_PM_LS_LHEN_X2%ISOLN_21 0.043368
R_x_PM_LS_LHEN_X2%ISOLN_r14 x_PM_LS_LHEN_X2%ISOLN_19 x_PM_LS_LHEN_X2%ISOLN_24 15.34
R_x_PM_LS_LHEN_X2%ISOLN_r15 x_PM_LS_LHEN_X2%ISOLN_15 x_PM_LS_LHEN_X2%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X2%ISOLN_r16 x_PM_LS_LHEN_X2%ISOLN_15 N_ISOLN_M4_g 56.55
R_x_PM_LS_LHEN_X2%ISOLN_r17 x_PM_LS_LHEN_X2%ISOLN_11 x_PM_LS_LHEN_X2%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X2%ISOLN_r18 x_PM_LS_LHEN_X2%ISOLN_11 N_ISOLN_M13_g 75.66
R_x_PM_LS_LHEN_X2%ISOLN_r19 x_PM_LS_LHEN_X2%ISOLN_8 x_PM_LS_LHEN_X2%ISOLN_19 4.58872
R_x_PM_LS_LHEN_X2%ISOLN_r20 x_PM_LS_LHEN_X2%ISOLN_8 N_ISOLN_M12_g 65.52
R_x_PM_LS_LHEN_X2%ISOLN_r21 x_PM_LS_LHEN_X2%ISOLN_7 N_ISOLN_M12_g 27.3
R_x_PM_LS_LHEN_X2%ISOLN_r22 x_PM_LS_LHEN_X2%ISOLN_5 x_PM_LS_LHEN_X2%ISOLN_7 4.35808
R_x_PM_LS_LHEN_X2%ISOLN_r23 x_PM_LS_LHEN_X2%ISOLN_5 x_PM_LS_LHEN_X2%ISOLN_6 104.52
R_x_PM_LS_LHEN_X2%ISOLN_r24 x_PM_LS_LHEN_X2%ISOLN_1 x_PM_LS_LHEN_X2%ISOLN_6 4.35808
R_x_PM_LS_LHEN_X2%ISOLN_r25 x_PM_LS_LHEN_X2%ISOLN_1 N_ISOLN_M9_g 27.3
C_x_PM_LS_LHEN_X2%10_c0 x_PM_LS_LHEN_X2%10_28 VSS 0.0133096f
C_x_PM_LS_LHEN_X2%10_c1 x_PM_LS_LHEN_X2%10_24 VSS 0.0958285f
C_x_PM_LS_LHEN_X2%10_c2 x_PM_LS_LHEN_X2%10_20 VSS 0.00757647f
C_x_PM_LS_LHEN_X2%10_c3 x_PM_LS_LHEN_X2%10_19 VSS 0.0319999f
C_x_PM_LS_LHEN_X2%10_c4 N_10_M4_d VSS 0.041437f
C_x_PM_LS_LHEN_X2%10_c5 x_PM_LS_LHEN_X2%10_14 VSS 0.016301f
C_x_PM_LS_LHEN_X2%10_c6 x_PM_LS_LHEN_X2%10_13 VSS 0.0837186f
C_x_PM_LS_LHEN_X2%10_c7 x_PM_LS_LHEN_X2%10_12 VSS 0.0404344f
C_x_PM_LS_LHEN_X2%10_c8 N_10_M6_g VSS 0.0650397f
C_x_PM_LS_LHEN_X2%10_c9 N_10_M15_g VSS 0.0547393f
R_x_PM_LS_LHEN_X2%10_r10 x_PM_LS_LHEN_X2%10_26 x_PM_LS_LHEN_X2%10_28 4.94
R_x_PM_LS_LHEN_X2%10_r11 x_PM_LS_LHEN_X2%10_24 x_PM_LS_LHEN_X2%10_26 25.0012
R_x_PM_LS_LHEN_X2%10_r12 x_PM_LS_LHEN_X2%10_22 x_PM_LS_LHEN_X2%10_24 1.09929
R_x_PM_LS_LHEN_X2%10_r13 x_PM_LS_LHEN_X2%10_21 x_PM_LS_LHEN_X2%10_24 1.045
R_x_PM_LS_LHEN_X2%10_r14 x_PM_LS_LHEN_X2%10_19 x_PM_LS_LHEN_X2%10_22 0.212317
R_x_PM_LS_LHEN_X2%10_r15 x_PM_LS_LHEN_X2%10_19 x_PM_LS_LHEN_X2%10_20 0.895714
R_x_PM_LS_LHEN_X2%10_r16 x_PM_LS_LHEN_X2%10_15 x_PM_LS_LHEN_X2%10_20 0.212317
R_x_PM_LS_LHEN_X2%10_r17 x_PM_LS_LHEN_X2%10_15 N_10_M4_d 1.15357
R_x_PM_LS_LHEN_X2%10_r18 x_PM_LS_LHEN_X2%10_13 x_PM_LS_LHEN_X2%10_21 0.212317
R_x_PM_LS_LHEN_X2%10_r19 x_PM_LS_LHEN_X2%10_13 x_PM_LS_LHEN_X2%10_14 1.9
R_x_PM_LS_LHEN_X2%10_r20 x_PM_LS_LHEN_X2%10_12 x_PM_LS_LHEN_X2%10_14 0.212317
R_x_PM_LS_LHEN_X2%10_r21 N_10_M13_s x_PM_LS_LHEN_X2%10_12 0.543196
R_x_PM_LS_LHEN_X2%10_r22 x_PM_LS_LHEN_X2%10_5 x_PM_LS_LHEN_X2%10_28 1.95
R_x_PM_LS_LHEN_X2%10_r23 x_PM_LS_LHEN_X2%10_5 N_10_M6_g 61.62
R_x_PM_LS_LHEN_X2%10_r24 x_PM_LS_LHEN_X2%10_1 x_PM_LS_LHEN_X2%10_28 1.95
R_x_PM_LS_LHEN_X2%10_r25 x_PM_LS_LHEN_X2%10_1 N_10_M15_g 56.16
C_x_PM_LS_LHEN_X2%Z_c0 N_Z_M15_d VSS 0.15161f
R_x_PM_LS_LHEN_X2%Z_r1 Z N_Z_M6_d 2.64643
R_x_PM_LS_LHEN_X2%Z_r2 N_Z_M15_d Z 1.91357
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_LHEN_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LHEN_X4 VDD VSS A VDDL ISOLN Z
*.PININFO VDD:P VDDL:P VSS:G A:I ISOLN:I Z:O
*.EQN Z=(A * ISOLN)
M_M9 N_VDDL_M0_d N_A_M0_g N_4_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=9e-08
M_M10 N_6_M1_d N_4_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=9e-08
M_M11 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=9e-08
M_M12 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=9e-08
M_M13 N_10_M4_d N_ISOLN_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1e-07
M_M14 N_VDD_M5_d N_8_M5_g N_10_M4_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1e-07
M_M15 N_Z_M6_d N_10_M6_g N_VDD_M5_d N_VDD_M2_b PMOS_VTL L=5e-08 W=5.9e-07
M_M0 N_VSS_M7_d N_A_M7_g N_4_M7_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M8_d N_4_M8_g N_VSS_M7_d N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M2 12 N_ISOLN_M9_g N_VSS_M9_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_7_M10_d N_6_M10_g 12 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M4 13 N_4_M11_g N_8_M11_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M5 N_VSS_M12_d N_ISOLN_M12_g 13 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M6 14 N_ISOLN_M13_g N_10_M13_s N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M7 N_VSS_M14_d N_8_M14_g 14 N_VSS_M7_b NMOS_VTL L=5e-08 W=9e-08
M_M8 N_Z_M15_d N_10_M15_g N_VSS_M14_d N_VSS_M7_b NMOS_VTL L=5e-08 W=3.5e-07
C_x_PM_LS_LHEN_X4%VDD_c0 x_PM_LS_LHEN_X4%VDD_51 VSS 0.0273284f
C_x_PM_LS_LHEN_X4%VDD_c1 x_PM_LS_LHEN_X4%VDD_48 VSS 0.0029494f
C_x_PM_LS_LHEN_X4%VDD_c2 x_PM_LS_LHEN_X4%VDD_47 VSS 0.0029494f
C_x_PM_LS_LHEN_X4%VDD_c3 x_PM_LS_LHEN_X4%VDD_46 VSS 0.00564441f
C_x_PM_LS_LHEN_X4%VDD_c4 x_PM_LS_LHEN_X4%VDD_45 VSS 0.0108319f
C_x_PM_LS_LHEN_X4%VDD_c5 x_PM_LS_LHEN_X4%VDD_44 VSS 0.2334f
C_x_PM_LS_LHEN_X4%VDD_c6 x_PM_LS_LHEN_X4%VDD_35 VSS 0.261567f
C_x_PM_LS_LHEN_X4%VDD_c7 N_VDD_M5_d VSS 0.0390005f
C_x_PM_LS_LHEN_X4%VDD_c8 x_PM_LS_LHEN_X4%VDD_27 VSS 0.026785f
C_x_PM_LS_LHEN_X4%VDD_c9 N_VDD_M4_s VSS 0.0235568f
C_x_PM_LS_LHEN_X4%VDD_c10 x_PM_LS_LHEN_X4%VDD_21 VSS 0.038264f
C_x_PM_LS_LHEN_X4%VDD_c11 N_VDD_M2_d VSS 0.0448495f
C_x_PM_LS_LHEN_X4%VDD_c12 x_PM_LS_LHEN_X4%VDD_15 VSS 0.123228f
C_x_PM_LS_LHEN_X4%VDD_c13 x_PM_LS_LHEN_X4%VDD_14 VSS 0.0192462f
C_x_PM_LS_LHEN_X4%VDD_c14 x_PM_LS_LHEN_X4%VDD_10 VSS 0.706493f
R_x_PM_LS_LHEN_X4%VDD_r15 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_51 0.13879
R_x_PM_LS_LHEN_X4%VDD_r16 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_45 0.138595
R_x_PM_LS_LHEN_X4%VDD_r17 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_44 0.138985
R_x_PM_LS_LHEN_X4%VDD_r18 N_VDD_M2_b x_PM_LS_LHEN_X4%VDD_35 0.13879
R_x_PM_LS_LHEN_X4%VDD_r19 x_PM_LS_LHEN_X4%VDD_35 VDD 3.84471
R_x_PM_LS_LHEN_X4%VDD_r20 x_PM_LS_LHEN_X4%VDD_34 x_PM_LS_LHEN_X4%VDD_48 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r21 x_PM_LS_LHEN_X4%VDD_51 x_PM_LS_LHEN_X4%VDD_34 0.659412
R_x_PM_LS_LHEN_X4%VDD_r22 x_PM_LS_LHEN_X4%VDD_29 x_PM_LS_LHEN_X4%VDD_48 0.145286
R_x_PM_LS_LHEN_X4%VDD_r23 x_PM_LS_LHEN_X4%VDD_29 N_VDD_M5_d 0.800714
R_x_PM_LS_LHEN_X4%VDD_r24 x_PM_LS_LHEN_X4%VDD_28 x_PM_LS_LHEN_X4%VDD_47 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r25 x_PM_LS_LHEN_X4%VDD_27 x_PM_LS_LHEN_X4%VDD_48 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r26 x_PM_LS_LHEN_X4%VDD_27 x_PM_LS_LHEN_X4%VDD_28 0.692941
R_x_PM_LS_LHEN_X4%VDD_r27 x_PM_LS_LHEN_X4%VDD_23 x_PM_LS_LHEN_X4%VDD_47 0.145286
R_x_PM_LS_LHEN_X4%VDD_r28 x_PM_LS_LHEN_X4%VDD_23 N_VDD_M4_s 0.800714
R_x_PM_LS_LHEN_X4%VDD_r29 x_PM_LS_LHEN_X4%VDD_22 x_PM_LS_LHEN_X4%VDD_46 0.132285
R_x_PM_LS_LHEN_X4%VDD_r30 x_PM_LS_LHEN_X4%VDD_21 x_PM_LS_LHEN_X4%VDD_47 0.0731438
R_x_PM_LS_LHEN_X4%VDD_r31 x_PM_LS_LHEN_X4%VDD_21 x_PM_LS_LHEN_X4%VDD_22 0.961176
R_x_PM_LS_LHEN_X4%VDD_r32 x_PM_LS_LHEN_X4%VDD_17 x_PM_LS_LHEN_X4%VDD_46 0.0680382
R_x_PM_LS_LHEN_X4%VDD_r33 x_PM_LS_LHEN_X4%VDD_17 N_VDD_M2_d 0.344815
R_x_PM_LS_LHEN_X4%VDD_r34 x_PM_LS_LHEN_X4%VDD_15 x_PM_LS_LHEN_X4%VDD_46 0.132285
R_x_PM_LS_LHEN_X4%VDD_r35 x_PM_LS_LHEN_X4%VDD_15 x_PM_LS_LHEN_X4%VDD_45 3.21882
R_x_PM_LS_LHEN_X4%VDD_r36 x_PM_LS_LHEN_X4%VDD_14 N_VDD_M2_b 0.140282
R_x_PM_LS_LHEN_X4%VDD_r37 x_PM_LS_LHEN_X4%VDD_44 x_PM_LS_LHEN_X4%VDD_14 7.68941
R_x_PM_LS_LHEN_X4%VDD_r38 x_PM_LS_LHEN_X4%VDD_10 VDD 11.0647
C_x_PM_LS_LHEN_X4%VSS_c0 x_PM_LS_LHEN_X4%VSS_57 VSS 0.00564441f
C_x_PM_LS_LHEN_X4%VSS_c1 x_PM_LS_LHEN_X4%VSS_56 VSS 0.00283507f
C_x_PM_LS_LHEN_X4%VSS_c2 x_PM_LS_LHEN_X4%VSS_55 VSS 0.00283861f
C_x_PM_LS_LHEN_X4%VSS_c3 x_PM_LS_LHEN_X4%VSS_54 VSS 0.00293741f
C_x_PM_LS_LHEN_X4%VSS_c4 x_PM_LS_LHEN_X4%VSS_52 VSS 0.2334f
C_x_PM_LS_LHEN_X4%VSS_c5 N_VSS_M7_b VSS 0.261566f
C_x_PM_LS_LHEN_X4%VSS_c6 x_PM_LS_LHEN_X4%VSS_42 VSS 0.025263f
C_x_PM_LS_LHEN_X4%VSS_c7 N_VSS_M14_d VSS 0.044101f
C_x_PM_LS_LHEN_X4%VSS_c8 x_PM_LS_LHEN_X4%VSS_36 VSS 0.0418001f
C_x_PM_LS_LHEN_X4%VSS_c9 N_VSS_M12_d VSS 0.0417755f
C_x_PM_LS_LHEN_X4%VSS_c10 x_PM_LS_LHEN_X4%VSS_28 VSS 0.0913087f
C_x_PM_LS_LHEN_X4%VSS_c11 N_VSS_M9_s VSS 0.048479f
C_x_PM_LS_LHEN_X4%VSS_c12 x_PM_LS_LHEN_X4%VSS_22 VSS 0.0334138f
C_x_PM_LS_LHEN_X4%VSS_c13 N_VSS_M7_d VSS 0.0412798f
C_x_PM_LS_LHEN_X4%VSS_c14 x_PM_LS_LHEN_X4%VSS_17 VSS 0.0106021f
C_x_PM_LS_LHEN_X4%VSS_c15 x_PM_LS_LHEN_X4%VSS_16 VSS 0.0548055f
C_x_PM_LS_LHEN_X4%VSS_c16 x_PM_LS_LHEN_X4%VSS_13 VSS 0.706493f
C_x_PM_LS_LHEN_X4%VSS_c17 x_PM_LS_LHEN_X4%VSS_12 VSS 0.0192462f
R_x_PM_LS_LHEN_X4%VSS_r18 N_VSS_M7_b x_PM_LS_LHEN_X4%VSS_52 0.138985
R_x_PM_LS_LHEN_X4%VSS_r19 x_PM_LS_LHEN_X4%VSS_43 x_PM_LS_LHEN_X4%VSS_57 0.132285
R_x_PM_LS_LHEN_X4%VSS_r20 N_VSS_M7_b x_PM_LS_LHEN_X4%VSS_42 0.13879
R_x_PM_LS_LHEN_X4%VSS_r21 x_PM_LS_LHEN_X4%VSS_42 x_PM_LS_LHEN_X4%VSS_43 0.592353
R_x_PM_LS_LHEN_X4%VSS_r22 x_PM_LS_LHEN_X4%VSS_38 x_PM_LS_LHEN_X4%VSS_57 0.0680382
R_x_PM_LS_LHEN_X4%VSS_r23 x_PM_LS_LHEN_X4%VSS_38 N_VSS_M14_d 0.358889
R_x_PM_LS_LHEN_X4%VSS_r24 x_PM_LS_LHEN_X4%VSS_37 x_PM_LS_LHEN_X4%VSS_56 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r25 x_PM_LS_LHEN_X4%VSS_36 x_PM_LS_LHEN_X4%VSS_57 0.132285
R_x_PM_LS_LHEN_X4%VSS_r26 x_PM_LS_LHEN_X4%VSS_36 x_PM_LS_LHEN_X4%VSS_37 0.961176
R_x_PM_LS_LHEN_X4%VSS_r27 x_PM_LS_LHEN_X4%VSS_32 x_PM_LS_LHEN_X4%VSS_56 0.145286
R_x_PM_LS_LHEN_X4%VSS_r28 x_PM_LS_LHEN_X4%VSS_32 N_VSS_M12_d 0.990714
R_x_PM_LS_LHEN_X4%VSS_r29 x_PM_LS_LHEN_X4%VSS_29 x_PM_LS_LHEN_X4%VSS_55 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r30 x_PM_LS_LHEN_X4%VSS_29 VSS 0.793529
R_x_PM_LS_LHEN_X4%VSS_r31 x_PM_LS_LHEN_X4%VSS_28 x_PM_LS_LHEN_X4%VSS_56 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r32 x_PM_LS_LHEN_X4%VSS_28 VSS 1.06176
R_x_PM_LS_LHEN_X4%VSS_r33 x_PM_LS_LHEN_X4%VSS_24 x_PM_LS_LHEN_X4%VSS_55 0.145286
R_x_PM_LS_LHEN_X4%VSS_r34 x_PM_LS_LHEN_X4%VSS_24 N_VSS_M9_s 1.045
R_x_PM_LS_LHEN_X4%VSS_r35 x_PM_LS_LHEN_X4%VSS_23 x_PM_LS_LHEN_X4%VSS_54 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r36 x_PM_LS_LHEN_X4%VSS_22 x_PM_LS_LHEN_X4%VSS_55 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r37 x_PM_LS_LHEN_X4%VSS_22 x_PM_LS_LHEN_X4%VSS_23 0.670588
R_x_PM_LS_LHEN_X4%VSS_r38 x_PM_LS_LHEN_X4%VSS_18 x_PM_LS_LHEN_X4%VSS_54 0.145286
R_x_PM_LS_LHEN_X4%VSS_r39 x_PM_LS_LHEN_X4%VSS_18 N_VSS_M7_d 0.637857
R_x_PM_LS_LHEN_X4%VSS_r40 N_VSS_M7_b x_PM_LS_LHEN_X4%VSS_17 0.138595
R_x_PM_LS_LHEN_X4%VSS_r41 x_PM_LS_LHEN_X4%VSS_16 x_PM_LS_LHEN_X4%VSS_54 0.0731438
R_x_PM_LS_LHEN_X4%VSS_r42 x_PM_LS_LHEN_X4%VSS_16 x_PM_LS_LHEN_X4%VSS_17 1.29647
R_x_PM_LS_LHEN_X4%VSS_r43 x_PM_LS_LHEN_X4%VSS_13 VSS 11.0647
R_x_PM_LS_LHEN_X4%VSS_r44 x_PM_LS_LHEN_X4%VSS_12 N_VSS_M7_b 0.140282
R_x_PM_LS_LHEN_X4%VSS_r45 x_PM_LS_LHEN_X4%VSS_52 x_PM_LS_LHEN_X4%VSS_12 7.68941
C_x_PM_LS_LHEN_X4%A_c0 x_PM_LS_LHEN_X4%A_21 VSS 0.0115399f
C_x_PM_LS_LHEN_X4%A_c1 x_PM_LS_LHEN_X4%A_14 VSS 0.08025f
C_x_PM_LS_LHEN_X4%A_c2 x_PM_LS_LHEN_X4%A_13 VSS 0.00484677f
C_x_PM_LS_LHEN_X4%A_c3 A VSS 0.0221181f
C_x_PM_LS_LHEN_X4%A_c4 N_A_M0_g VSS 0.0395466f
C_x_PM_LS_LHEN_X4%A_c5 N_A_M7_g VSS 0.0431614f
R_x_PM_LS_LHEN_X4%A_r6 x_PM_LS_LHEN_X4%A_16 x_PM_LS_LHEN_X4%A_21 3.38
R_x_PM_LS_LHEN_X4%A_r7 x_PM_LS_LHEN_X4%A_18 x_PM_LS_LHEN_X4%A_16 1.3
R_x_PM_LS_LHEN_X4%A_r8 x_PM_LS_LHEN_X4%A_14 x_PM_LS_LHEN_X4%A_16 25.0012
R_x_PM_LS_LHEN_X4%A_r9 x_PM_LS_LHEN_X4%A_13 x_PM_LS_LHEN_X4%A_14 0.936429
R_x_PM_LS_LHEN_X4%A_r10 x_PM_LS_LHEN_X4%A_9 x_PM_LS_LHEN_X4%A_13 0.212317
R_x_PM_LS_LHEN_X4%A_r11 x_PM_LS_LHEN_X4%A_9 A 0.488571
R_x_PM_LS_LHEN_X4%A_r12 x_PM_LS_LHEN_X4%A_5 x_PM_LS_LHEN_X4%A_21 1.95
R_x_PM_LS_LHEN_X4%A_r13 x_PM_LS_LHEN_X4%A_5 N_A_M0_g 35.1
R_x_PM_LS_LHEN_X4%A_r14 x_PM_LS_LHEN_X4%A_1 x_PM_LS_LHEN_X4%A_18 1.95
R_x_PM_LS_LHEN_X4%A_r15 x_PM_LS_LHEN_X4%A_1 N_A_M7_g 39.78
C_x_PM_LS_LHEN_X4%4_c0 x_PM_LS_LHEN_X4%4_38 VSS 0.0568294f
C_x_PM_LS_LHEN_X4%4_c1 x_PM_LS_LHEN_X4%4_34 VSS 0.0283584f
C_x_PM_LS_LHEN_X4%4_c2 x_PM_LS_LHEN_X4%4_33 VSS 0.0640268f
C_x_PM_LS_LHEN_X4%4_c3 x_PM_LS_LHEN_X4%4_32 VSS 0.0175053f
C_x_PM_LS_LHEN_X4%4_c4 x_PM_LS_LHEN_X4%4_31 VSS 0.0602627f
C_x_PM_LS_LHEN_X4%4_c5 N_4_M0_s VSS 0.0282286f
C_x_PM_LS_LHEN_X4%4_c6 N_4_M7_s VSS 0.0341836f
C_x_PM_LS_LHEN_X4%4_c7 x_PM_LS_LHEN_X4%4_17 VSS 0.0240064f
C_x_PM_LS_LHEN_X4%4_c8 N_4_M11_g VSS 0.0507166f
C_x_PM_LS_LHEN_X4%4_c9 x_PM_LS_LHEN_X4%4_11 VSS 0.0692516f
C_x_PM_LS_LHEN_X4%4_c10 x_PM_LS_LHEN_X4%4_10 VSS 0.0103126f
C_x_PM_LS_LHEN_X4%4_c11 x_PM_LS_LHEN_X4%4_9 VSS 0.0242023f
C_x_PM_LS_LHEN_X4%4_c12 N_4_M1_g VSS 0.0326218f
C_x_PM_LS_LHEN_X4%4_c13 N_4_M8_g VSS 0.0364027f
R_x_PM_LS_LHEN_X4%4_r14 x_PM_LS_LHEN_X4%4_42 x_PM_LS_LHEN_X4%4_43 4.68
R_x_PM_LS_LHEN_X4%4_r15 x_PM_LS_LHEN_X4%4_40 x_PM_LS_LHEN_X4%4_42 0.78
R_x_PM_LS_LHEN_X4%4_r16 x_PM_LS_LHEN_X4%4_38 x_PM_LS_LHEN_X4%4_40 25.0012
R_x_PM_LS_LHEN_X4%4_r17 x_PM_LS_LHEN_X4%4_36 x_PM_LS_LHEN_X4%4_38 0.556429
R_x_PM_LS_LHEN_X4%4_r18 x_PM_LS_LHEN_X4%4_35 x_PM_LS_LHEN_X4%4_38 0.529286
R_x_PM_LS_LHEN_X4%4_r19 x_PM_LS_LHEN_X4%4_33 x_PM_LS_LHEN_X4%4_36 0.212317
R_x_PM_LS_LHEN_X4%4_r20 x_PM_LS_LHEN_X4%4_33 x_PM_LS_LHEN_X4%4_34 0.868571
R_x_PM_LS_LHEN_X4%4_r21 x_PM_LS_LHEN_X4%4_31 x_PM_LS_LHEN_X4%4_35 0.212317
R_x_PM_LS_LHEN_X4%4_r22 x_PM_LS_LHEN_X4%4_31 x_PM_LS_LHEN_X4%4_32 1.11286
R_x_PM_LS_LHEN_X4%4_r23 x_PM_LS_LHEN_X4%4_27 x_PM_LS_LHEN_X4%4_34 0.212317
R_x_PM_LS_LHEN_X4%4_r24 x_PM_LS_LHEN_X4%4_27 N_4_M0_s 0.475
R_x_PM_LS_LHEN_X4%4_r25 x_PM_LS_LHEN_X4%4_23 x_PM_LS_LHEN_X4%4_32 0.212317
R_x_PM_LS_LHEN_X4%4_r26 x_PM_LS_LHEN_X4%4_23 N_4_M7_s 0.637857
R_x_PM_LS_LHEN_X4%4_r27 x_PM_LS_LHEN_X4%4_17 x_PM_LS_LHEN_X4%4_19 11.96
R_x_PM_LS_LHEN_X4%4_r28 x_PM_LS_LHEN_X4%4_13 N_4_M11_g 47.58
R_x_PM_LS_LHEN_X4%4_r29 x_PM_LS_LHEN_X4%4_12 x_PM_LS_LHEN_X4%4_19 1.95
R_x_PM_LS_LHEN_X4%4_r30 x_PM_LS_LHEN_X4%4_11 x_PM_LS_LHEN_X4%4_13 4.58872
R_x_PM_LS_LHEN_X4%4_r31 x_PM_LS_LHEN_X4%4_11 x_PM_LS_LHEN_X4%4_12 54.6
R_x_PM_LS_LHEN_X4%4_r32 x_PM_LS_LHEN_X4%4_10 x_PM_LS_LHEN_X4%4_43 2.6
R_x_PM_LS_LHEN_X4%4_r33 x_PM_LS_LHEN_X4%4_9 x_PM_LS_LHEN_X4%4_17 1.95
R_x_PM_LS_LHEN_X4%4_r34 x_PM_LS_LHEN_X4%4_9 x_PM_LS_LHEN_X4%4_10 20.28
R_x_PM_LS_LHEN_X4%4_r35 x_PM_LS_LHEN_X4%4_5 x_PM_LS_LHEN_X4%4_43 1.95
R_x_PM_LS_LHEN_X4%4_r36 x_PM_LS_LHEN_X4%4_5 N_4_M1_g 35.1
R_x_PM_LS_LHEN_X4%4_r37 x_PM_LS_LHEN_X4%4_1 x_PM_LS_LHEN_X4%4_42 1.95
R_x_PM_LS_LHEN_X4%4_r38 x_PM_LS_LHEN_X4%4_1 N_4_M8_g 39.78
C_x_PM_LS_LHEN_X4%VDDL_c0 VDDL VSS 0.0679693f
C_x_PM_LS_LHEN_X4%VDDL_c1 x_PM_LS_LHEN_X4%VDDL_6 VSS 0.0646917f
R_x_PM_LS_LHEN_X4%VDDL_r2 x_PM_LS_LHEN_X4%VDDL_11 VDDL 0.16625
R_x_PM_LS_LHEN_X4%VDDL_r3 N_VDDL_M0_b x_PM_LS_LHEN_X4%VDDL_11 0.0095
R_x_PM_LS_LHEN_X4%VDDL_r4 x_PM_LS_LHEN_X4%VDDL_6 x_PM_LS_LHEN_X4%VDDL_11 0.095
R_x_PM_LS_LHEN_X4%VDDL_r5 N_VDDL_M0_d x_PM_LS_LHEN_X4%VDDL_6 0.347287
C_x_PM_LS_LHEN_X4%6_c0 x_PM_LS_LHEN_X4%6_28 VSS 0.0148235f
C_x_PM_LS_LHEN_X4%6_c1 x_PM_LS_LHEN_X4%6_25 VSS 0.0180551f
C_x_PM_LS_LHEN_X4%6_c2 x_PM_LS_LHEN_X4%6_23 VSS 0.0459741f
C_x_PM_LS_LHEN_X4%6_c3 x_PM_LS_LHEN_X4%6_17 VSS 0.0210126f
C_x_PM_LS_LHEN_X4%6_c4 x_PM_LS_LHEN_X4%6_13 VSS 0.0479047f
C_x_PM_LS_LHEN_X4%6_c5 N_6_M1_d VSS 0.0480368f
C_x_PM_LS_LHEN_X4%6_c6 x_PM_LS_LHEN_X4%6_8 VSS 0.0495792f
C_x_PM_LS_LHEN_X4%6_c7 N_6_M10_g VSS 0.0281997f
R_x_PM_LS_LHEN_X4%6_r8 x_PM_LS_LHEN_X4%6_26 x_PM_LS_LHEN_X4%6_28 4.42
R_x_PM_LS_LHEN_X4%6_r9 N_6_M8_d x_PM_LS_LHEN_X4%6_23 0.230714
R_x_PM_LS_LHEN_X4%6_r10 x_PM_LS_LHEN_X4%6_17 x_PM_LS_LHEN_X4%6_26 25.0012
R_x_PM_LS_LHEN_X4%6_r11 x_PM_LS_LHEN_X4%6_15 x_PM_LS_LHEN_X4%6_17 0.285
R_x_PM_LS_LHEN_X4%6_r12 x_PM_LS_LHEN_X4%6_14 x_PM_LS_LHEN_X4%6_25 0.0418175
R_x_PM_LS_LHEN_X4%6_r13 x_PM_LS_LHEN_X4%6_13 x_PM_LS_LHEN_X4%6_15 0.212317
R_x_PM_LS_LHEN_X4%6_r14 x_PM_LS_LHEN_X4%6_13 x_PM_LS_LHEN_X4%6_14 1.62857
R_x_PM_LS_LHEN_X4%6_r15 x_PM_LS_LHEN_X4%6_9 x_PM_LS_LHEN_X4%6_25 0.160909
R_x_PM_LS_LHEN_X4%6_r16 x_PM_LS_LHEN_X4%6_9 N_6_M1_d 1.045
R_x_PM_LS_LHEN_X4%6_r17 x_PM_LS_LHEN_X4%6_8 x_PM_LS_LHEN_X4%6_25 0.160909
R_x_PM_LS_LHEN_X4%6_r18 x_PM_LS_LHEN_X4%6_7 x_PM_LS_LHEN_X4%6_23 0.095
R_x_PM_LS_LHEN_X4%6_r19 x_PM_LS_LHEN_X4%6_7 x_PM_LS_LHEN_X4%6_8 1.38429
R_x_PM_LS_LHEN_X4%6_r20 x_PM_LS_LHEN_X4%6_1 x_PM_LS_LHEN_X4%6_28 1.95
R_x_PM_LS_LHEN_X4%6_r21 x_PM_LS_LHEN_X4%6_1 N_6_M10_g 21.06
C_x_PM_LS_LHEN_X4%7_c0 x_PM_LS_LHEN_X4%7_21 VSS 0.0222597f
C_x_PM_LS_LHEN_X4%7_c1 x_PM_LS_LHEN_X4%7_18 VSS 0.00760338f
C_x_PM_LS_LHEN_X4%7_c2 x_PM_LS_LHEN_X4%7_17 VSS 0.0402919f
C_x_PM_LS_LHEN_X4%7_c3 N_7_M2_s VSS 0.0696407f
C_x_PM_LS_LHEN_X4%7_c4 N_7_M10_d VSS 0.107281f
C_x_PM_LS_LHEN_X4%7_c5 N_7_M3_g VSS 0.0536298f
R_x_PM_LS_LHEN_X4%7_r6 x_PM_LS_LHEN_X4%7_17 x_PM_LS_LHEN_X4%7_18 0.0341169
R_x_PM_LS_LHEN_X4%7_r7 x_PM_LS_LHEN_X4%7_16 x_PM_LS_LHEN_X4%7_21 6.65294
R_x_PM_LS_LHEN_X4%7_r8 x_PM_LS_LHEN_X4%7_15 x_PM_LS_LHEN_X4%7_17 0.533203
R_x_PM_LS_LHEN_X4%7_r9 x_PM_LS_LHEN_X4%7_15 x_PM_LS_LHEN_X4%7_16 25.0012
R_x_PM_LS_LHEN_X4%7_r10 x_PM_LS_LHEN_X4%7_11 x_PM_LS_LHEN_X4%7_18 0.170353
R_x_PM_LS_LHEN_X4%7_r11 x_PM_LS_LHEN_X4%7_7 x_PM_LS_LHEN_X4%7_18 0.170353
R_x_PM_LS_LHEN_X4%7_r12 x_PM_LS_LHEN_X4%7_7 N_7_M2_s 1.94071
R_x_PM_LS_LHEN_X4%7_r13 x_PM_LS_LHEN_X4%7_11 N_7_M10_d 2.59214
R_x_PM_LS_LHEN_X4%7_r14 x_PM_LS_LHEN_X4%7_1 x_PM_LS_LHEN_X4%7_21 1.95
R_x_PM_LS_LHEN_X4%7_r15 x_PM_LS_LHEN_X4%7_1 N_7_M3_g 55.38
C_x_PM_LS_LHEN_X4%8_c0 x_PM_LS_LHEN_X4%8_47 VSS 0.0100619f
C_x_PM_LS_LHEN_X4%8_c1 x_PM_LS_LHEN_X4%8_40 VSS 0.00342345f
C_x_PM_LS_LHEN_X4%8_c2 x_PM_LS_LHEN_X4%8_37 VSS 0.109784f
C_x_PM_LS_LHEN_X4%8_c3 x_PM_LS_LHEN_X4%8_31 VSS 0.0182707f
C_x_PM_LS_LHEN_X4%8_c4 x_PM_LS_LHEN_X4%8_29 VSS 0.0483681f
C_x_PM_LS_LHEN_X4%8_c5 N_8_M3_d VSS 0.0400068f
C_x_PM_LS_LHEN_X4%8_c6 x_PM_LS_LHEN_X4%8_24 VSS 0.0436236f
C_x_PM_LS_LHEN_X4%8_c7 x_PM_LS_LHEN_X4%8_22 VSS 0.0187278f
C_x_PM_LS_LHEN_X4%8_c8 x_PM_LS_LHEN_X4%8_21 VSS 0.0110674f
C_x_PM_LS_LHEN_X4%8_c9 x_PM_LS_LHEN_X4%8_19 VSS 0.021181f
C_x_PM_LS_LHEN_X4%8_c10 N_8_M11_s VSS 0.0539142f
C_x_PM_LS_LHEN_X4%8_c11 N_8_M5_g VSS 0.0758528f
C_x_PM_LS_LHEN_X4%8_c12 N_8_M14_g VSS 0.0375578f
C_x_PM_LS_LHEN_X4%8_c13 N_8_M2_g VSS 0.0313493f
R_x_PM_LS_LHEN_X4%8_r14 x_PM_LS_LHEN_X4%8_45 x_PM_LS_LHEN_X4%8_47 2.86
R_x_PM_LS_LHEN_X4%8_r15 x_PM_LS_LHEN_X4%8_37 x_PM_LS_LHEN_X4%8_45 25.0012
R_x_PM_LS_LHEN_X4%8_r16 x_PM_LS_LHEN_X4%8_35 x_PM_LS_LHEN_X4%8_37 3.24357
R_x_PM_LS_LHEN_X4%8_r17 x_PM_LS_LHEN_X4%8_41 x_PM_LS_LHEN_X4%8_31 3.44118
R_x_PM_LS_LHEN_X4%8_r18 x_PM_LS_LHEN_X4%8_29 x_PM_LS_LHEN_X4%8_31 25.0012
R_x_PM_LS_LHEN_X4%8_r19 x_PM_LS_LHEN_X4%8_29 x_PM_LS_LHEN_X4%8_33 0.156471
R_x_PM_LS_LHEN_X4%8_r20 x_PM_LS_LHEN_X4%8_25 x_PM_LS_LHEN_X4%8_40 0.188527
R_x_PM_LS_LHEN_X4%8_r21 x_PM_LS_LHEN_X4%8_25 N_8_M3_d 0.665
R_x_PM_LS_LHEN_X4%8_r22 x_PM_LS_LHEN_X4%8_24 x_PM_LS_LHEN_X4%8_40 0.188527
R_x_PM_LS_LHEN_X4%8_r23 x_PM_LS_LHEN_X4%8_23 x_PM_LS_LHEN_X4%8_35 0.095
R_x_PM_LS_LHEN_X4%8_r24 x_PM_LS_LHEN_X4%8_23 x_PM_LS_LHEN_X4%8_24 2.30714
R_x_PM_LS_LHEN_X4%8_r25 x_PM_LS_LHEN_X4%8_21 x_PM_LS_LHEN_X4%8_35 0.19
R_x_PM_LS_LHEN_X4%8_r26 x_PM_LS_LHEN_X4%8_21 x_PM_LS_LHEN_X4%8_22 0.624286
R_x_PM_LS_LHEN_X4%8_r27 x_PM_LS_LHEN_X4%8_20 x_PM_LS_LHEN_X4%8_33 0.095
R_x_PM_LS_LHEN_X4%8_r28 x_PM_LS_LHEN_X4%8_19 x_PM_LS_LHEN_X4%8_40 0.0203602
R_x_PM_LS_LHEN_X4%8_r29 x_PM_LS_LHEN_X4%8_19 x_PM_LS_LHEN_X4%8_20 0.715294
R_x_PM_LS_LHEN_X4%8_r30 x_PM_LS_LHEN_X4%8_15 x_PM_LS_LHEN_X4%8_22 0.212317
R_x_PM_LS_LHEN_X4%8_r31 x_PM_LS_LHEN_X4%8_15 N_8_M11_s 1.09929
R_x_PM_LS_LHEN_X4%8_r32 x_PM_LS_LHEN_X4%8_9 x_PM_LS_LHEN_X4%8_47 1.95
R_x_PM_LS_LHEN_X4%8_r33 x_PM_LS_LHEN_X4%8_9 N_8_M5_g 98.28
R_x_PM_LS_LHEN_X4%8_r34 x_PM_LS_LHEN_X4%8_5 x_PM_LS_LHEN_X4%8_47 1.95
R_x_PM_LS_LHEN_X4%8_r35 x_PM_LS_LHEN_X4%8_5 N_8_M14_g 39
R_x_PM_LS_LHEN_X4%8_r36 x_PM_LS_LHEN_X4%8_1 x_PM_LS_LHEN_X4%8_41 1.95
R_x_PM_LS_LHEN_X4%8_r37 x_PM_LS_LHEN_X4%8_1 N_8_M2_g 25.74
C_x_PM_LS_LHEN_X4%ISOLN_c0 ISOLN VSS 0.024821f
C_x_PM_LS_LHEN_X4%ISOLN_c1 x_PM_LS_LHEN_X4%ISOLN_21 VSS 0.00441236f
C_x_PM_LS_LHEN_X4%ISOLN_c2 x_PM_LS_LHEN_X4%ISOLN_20 VSS 0.0235163f
C_x_PM_LS_LHEN_X4%ISOLN_c3 x_PM_LS_LHEN_X4%ISOLN_19 VSS 0.00807449f
C_x_PM_LS_LHEN_X4%ISOLN_c4 N_ISOLN_M4_g VSS 0.0525128f
C_x_PM_LS_LHEN_X4%ISOLN_c5 N_ISOLN_M13_g VSS 0.0685409f
C_x_PM_LS_LHEN_X4%ISOLN_c6 N_ISOLN_M12_g VSS 0.0640436f
C_x_PM_LS_LHEN_X4%ISOLN_c7 x_PM_LS_LHEN_X4%ISOLN_6 VSS 0.00601436f
C_x_PM_LS_LHEN_X4%ISOLN_c8 x_PM_LS_LHEN_X4%ISOLN_5 VSS 0.0905403f
C_x_PM_LS_LHEN_X4%ISOLN_c9 N_ISOLN_M9_g VSS 0.0326862f
R_x_PM_LS_LHEN_X4%ISOLN_r10 x_PM_LS_LHEN_X4%ISOLN_22 x_PM_LS_LHEN_X4%ISOLN_24 25.0012
R_x_PM_LS_LHEN_X4%ISOLN_r11 x_PM_LS_LHEN_X4%ISOLN_22 ISOLN 0.169643
R_x_PM_LS_LHEN_X4%ISOLN_r12 x_PM_LS_LHEN_X4%ISOLN_20 x_PM_LS_LHEN_X4%ISOLN_24 13.78
R_x_PM_LS_LHEN_X4%ISOLN_r13 x_PM_LS_LHEN_X4%ISOLN_20 x_PM_LS_LHEN_X4%ISOLN_21 0.043368
R_x_PM_LS_LHEN_X4%ISOLN_r14 x_PM_LS_LHEN_X4%ISOLN_19 x_PM_LS_LHEN_X4%ISOLN_24 16.38
R_x_PM_LS_LHEN_X4%ISOLN_r15 x_PM_LS_LHEN_X4%ISOLN_15 x_PM_LS_LHEN_X4%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X4%ISOLN_r16 x_PM_LS_LHEN_X4%ISOLN_15 N_ISOLN_M4_g 62.4
R_x_PM_LS_LHEN_X4%ISOLN_r17 x_PM_LS_LHEN_X4%ISOLN_11 x_PM_LS_LHEN_X4%ISOLN_21 4.56151
R_x_PM_LS_LHEN_X4%ISOLN_r18 x_PM_LS_LHEN_X4%ISOLN_11 N_ISOLN_M13_g 74.88
R_x_PM_LS_LHEN_X4%ISOLN_r19 x_PM_LS_LHEN_X4%ISOLN_8 x_PM_LS_LHEN_X4%ISOLN_19 4.58872
R_x_PM_LS_LHEN_X4%ISOLN_r20 x_PM_LS_LHEN_X4%ISOLN_8 N_ISOLN_M12_g 65.52
R_x_PM_LS_LHEN_X4%ISOLN_r21 x_PM_LS_LHEN_X4%ISOLN_7 N_ISOLN_M12_g 26.52
R_x_PM_LS_LHEN_X4%ISOLN_r22 x_PM_LS_LHEN_X4%ISOLN_5 x_PM_LS_LHEN_X4%ISOLN_7 4.35808
R_x_PM_LS_LHEN_X4%ISOLN_r23 x_PM_LS_LHEN_X4%ISOLN_5 x_PM_LS_LHEN_X4%ISOLN_6 104.52
R_x_PM_LS_LHEN_X4%ISOLN_r24 x_PM_LS_LHEN_X4%ISOLN_1 x_PM_LS_LHEN_X4%ISOLN_6 4.35808
R_x_PM_LS_LHEN_X4%ISOLN_r25 x_PM_LS_LHEN_X4%ISOLN_1 N_ISOLN_M9_g 26.52
C_x_PM_LS_LHEN_X4%10_c0 x_PM_LS_LHEN_X4%10_30 VSS 0.0127458f
C_x_PM_LS_LHEN_X4%10_c1 x_PM_LS_LHEN_X4%10_26 VSS 0.122444f
C_x_PM_LS_LHEN_X4%10_c2 x_PM_LS_LHEN_X4%10_22 VSS 0.00626165f
C_x_PM_LS_LHEN_X4%10_c3 x_PM_LS_LHEN_X4%10_21 VSS 0.0374523f
C_x_PM_LS_LHEN_X4%10_c4 N_10_M4_d VSS 0.0391572f
C_x_PM_LS_LHEN_X4%10_c5 x_PM_LS_LHEN_X4%10_16 VSS 0.0173686f
C_x_PM_LS_LHEN_X4%10_c6 x_PM_LS_LHEN_X4%10_15 VSS 0.0971351f
C_x_PM_LS_LHEN_X4%10_c7 N_10_M13_s VSS 0.0420865f
C_x_PM_LS_LHEN_X4%10_c8 N_10_M6_g VSS 0.0774471f
C_x_PM_LS_LHEN_X4%10_c9 N_10_M15_g VSS 0.0511262f
R_x_PM_LS_LHEN_X4%10_r10 x_PM_LS_LHEN_X4%10_28 x_PM_LS_LHEN_X4%10_30 4.42
R_x_PM_LS_LHEN_X4%10_r11 x_PM_LS_LHEN_X4%10_26 x_PM_LS_LHEN_X4%10_28 25.0012
R_x_PM_LS_LHEN_X4%10_r12 x_PM_LS_LHEN_X4%10_24 x_PM_LS_LHEN_X4%10_26 1.995
R_x_PM_LS_LHEN_X4%10_r13 x_PM_LS_LHEN_X4%10_23 x_PM_LS_LHEN_X4%10_26 0.990714
R_x_PM_LS_LHEN_X4%10_r14 x_PM_LS_LHEN_X4%10_21 x_PM_LS_LHEN_X4%10_24 0.212317
R_x_PM_LS_LHEN_X4%10_r15 x_PM_LS_LHEN_X4%10_21 x_PM_LS_LHEN_X4%10_22 0.922857
R_x_PM_LS_LHEN_X4%10_r16 x_PM_LS_LHEN_X4%10_17 x_PM_LS_LHEN_X4%10_22 0.212317
R_x_PM_LS_LHEN_X4%10_r17 x_PM_LS_LHEN_X4%10_17 N_10_M4_d 0.773571
R_x_PM_LS_LHEN_X4%10_r18 x_PM_LS_LHEN_X4%10_15 x_PM_LS_LHEN_X4%10_23 0.212317
R_x_PM_LS_LHEN_X4%10_r19 x_PM_LS_LHEN_X4%10_15 x_PM_LS_LHEN_X4%10_16 1.95429
R_x_PM_LS_LHEN_X4%10_r20 x_PM_LS_LHEN_X4%10_11 x_PM_LS_LHEN_X4%10_16 0.212317
R_x_PM_LS_LHEN_X4%10_r21 x_PM_LS_LHEN_X4%10_11 N_10_M13_s 0.556429
R_x_PM_LS_LHEN_X4%10_r22 x_PM_LS_LHEN_X4%10_5 x_PM_LS_LHEN_X4%10_30 1.95
R_x_PM_LS_LHEN_X4%10_r23 x_PM_LS_LHEN_X4%10_5 N_10_M6_g 54.6
R_x_PM_LS_LHEN_X4%10_r24 x_PM_LS_LHEN_X4%10_1 x_PM_LS_LHEN_X4%10_30 1.95
R_x_PM_LS_LHEN_X4%10_r25 x_PM_LS_LHEN_X4%10_1 N_10_M15_g 35.88
C_x_PM_LS_LHEN_X4%Z_c0 N_Z_M15_d VSS 0.179332f
R_x_PM_LS_LHEN_X4%Z_r1 Z N_Z_M6_d 2.755
R_x_PM_LS_LHEN_X4%Z_r2 N_Z_M15_d Z 1.235
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_LH_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LH_X1 VDD VSS A VDDL Z
*.PININFO VDD:P VDDL:P VSS:G A:I Z:O
*.EQN Z=A
M_M5 N_VDDL_M0_d N_A_M0_g N_5_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.35e-07
M_M6 N_6_M1_d N_5_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.35e-07
M_M7 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M8 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M9 N_Z_M4_d N_8_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=2e-07
M_M0 N_VSS_M5_d N_A_M5_g N_5_M5_s N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M6_d N_5_M6_g N_VSS_M5_d N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M2 N_VSS_M7_d N_5_M7_g N_7_M7_s N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_8_M8_d N_6_M8_g N_VSS_M7_d N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M4 N_Z_M9_d N_8_M9_g N_VSS_M9_s N_VSS_M5_b NMOS_VTL L=5e-08 W=1.2e-07
C_x_PM_LS_LH_X1%VDD_c0 x_PM_LS_LH_X1%VDD_43 VSS 0.0237472f
C_x_PM_LS_LH_X1%VDD_c1 x_PM_LS_LH_X1%VDD_40 VSS 0.00293947f
C_x_PM_LS_LH_X1%VDD_c2 x_PM_LS_LH_X1%VDD_39 VSS 0.00295509f
C_x_PM_LS_LH_X1%VDD_c3 x_PM_LS_LH_X1%VDD_38 VSS 0.0107524f
C_x_PM_LS_LH_X1%VDD_c4 x_PM_LS_LH_X1%VDD_37 VSS 0.2334f
C_x_PM_LS_LH_X1%VDD_c5 x_PM_LS_LH_X1%VDD_28 VSS 0.261469f
C_x_PM_LS_LH_X1%VDD_c6 N_VDD_M4_s VSS 0.0194351f
C_x_PM_LS_LH_X1%VDD_c7 x_PM_LS_LH_X1%VDD_20 VSS 0.0243102f
C_x_PM_LS_LH_X1%VDD_c8 N_VDD_M2_d VSS 0.0342533f
C_x_PM_LS_LH_X1%VDD_c9 x_PM_LS_LH_X1%VDD_14 VSS 0.116013f
C_x_PM_LS_LH_X1%VDD_c10 x_PM_LS_LH_X1%VDD_13 VSS 0.0192462f
C_x_PM_LS_LH_X1%VDD_c11 x_PM_LS_LH_X1%VDD_9 VSS 0.667932f
R_x_PM_LS_LH_X1%VDD_r12 N_VDD_M2_b x_PM_LS_LH_X1%VDD_43 0.13879
R_x_PM_LS_LH_X1%VDD_r13 N_VDD_M2_b x_PM_LS_LH_X1%VDD_38 0.138595
R_x_PM_LS_LH_X1%VDD_r14 N_VDD_M2_b x_PM_LS_LH_X1%VDD_37 0.138985
R_x_PM_LS_LH_X1%VDD_r15 N_VDD_M2_b x_PM_LS_LH_X1%VDD_28 0.13879
R_x_PM_LS_LH_X1%VDD_r16 x_PM_LS_LH_X1%VDD_28 VDD 3.84471
R_x_PM_LS_LH_X1%VDD_r17 x_PM_LS_LH_X1%VDD_27 x_PM_LS_LH_X1%VDD_40 0.0731438
R_x_PM_LS_LH_X1%VDD_r18 x_PM_LS_LH_X1%VDD_43 x_PM_LS_LH_X1%VDD_27 0.659412
R_x_PM_LS_LH_X1%VDD_r19 x_PM_LS_LH_X1%VDD_22 x_PM_LS_LH_X1%VDD_40 0.145286
R_x_PM_LS_LH_X1%VDD_r20 x_PM_LS_LH_X1%VDD_22 N_VDD_M4_s 0.665
R_x_PM_LS_LH_X1%VDD_r21 x_PM_LS_LH_X1%VDD_21 x_PM_LS_LH_X1%VDD_39 0.0731438
R_x_PM_LS_LH_X1%VDD_r22 x_PM_LS_LH_X1%VDD_20 x_PM_LS_LH_X1%VDD_40 0.0731438
R_x_PM_LS_LH_X1%VDD_r23 x_PM_LS_LH_X1%VDD_20 x_PM_LS_LH_X1%VDD_21 0.737647
R_x_PM_LS_LH_X1%VDD_r24 x_PM_LS_LH_X1%VDD_16 x_PM_LS_LH_X1%VDD_39 0.145286
R_x_PM_LS_LH_X1%VDD_r25 x_PM_LS_LH_X1%VDD_16 N_VDD_M2_d 0.882143
R_x_PM_LS_LH_X1%VDD_r26 x_PM_LS_LH_X1%VDD_14 x_PM_LS_LH_X1%VDD_39 0.0731438
R_x_PM_LS_LH_X1%VDD_r27 x_PM_LS_LH_X1%VDD_14 x_PM_LS_LH_X1%VDD_38 3.16294
R_x_PM_LS_LH_X1%VDD_r28 x_PM_LS_LH_X1%VDD_13 N_VDD_M2_b 0.140282
R_x_PM_LS_LH_X1%VDD_r29 x_PM_LS_LH_X1%VDD_37 x_PM_LS_LH_X1%VDD_13 7.68941
R_x_PM_LS_LH_X1%VDD_r30 x_PM_LS_LH_X1%VDD_9 VDD 10.4276
C_x_PM_LS_LH_X1%VSS_c0 x_PM_LS_LH_X1%VSS_50 VSS 0.0271082f
C_x_PM_LS_LH_X1%VSS_c1 x_PM_LS_LH_X1%VSS_47 VSS 0.00315161f
C_x_PM_LS_LH_X1%VSS_c2 x_PM_LS_LH_X1%VSS_46 VSS 0.0029455f
C_x_PM_LS_LH_X1%VSS_c3 x_PM_LS_LH_X1%VSS_45 VSS 0.0029415f
C_x_PM_LS_LH_X1%VSS_c4 x_PM_LS_LH_X1%VSS_43 VSS 0.2334f
C_x_PM_LS_LH_X1%VSS_c5 N_VSS_M5_b VSS 0.261466f
C_x_PM_LS_LH_X1%VSS_c6 N_VSS_M9_s VSS 0.0307793f
C_x_PM_LS_LH_X1%VSS_c7 x_PM_LS_LH_X1%VSS_27 VSS 0.0291308f
C_x_PM_LS_LH_X1%VSS_c8 x_PM_LS_LH_X1%VSS_26 VSS 0.0420074f
C_x_PM_LS_LH_X1%VSS_c9 x_PM_LS_LH_X1%VSS_21 VSS 0.0920626f
C_x_PM_LS_LH_X1%VSS_c10 N_VSS_M5_d VSS 0.0405323f
C_x_PM_LS_LH_X1%VSS_c11 x_PM_LS_LH_X1%VSS_16 VSS 0.0106189f
C_x_PM_LS_LH_X1%VSS_c12 x_PM_LS_LH_X1%VSS_15 VSS 0.0597011f
C_x_PM_LS_LH_X1%VSS_c13 x_PM_LS_LH_X1%VSS_12 VSS 0.667932f
C_x_PM_LS_LH_X1%VSS_c14 x_PM_LS_LH_X1%VSS_11 VSS 0.0192462f
R_x_PM_LS_LH_X1%VSS_r15 N_VSS_M5_b x_PM_LS_LH_X1%VSS_50 0.13879
R_x_PM_LS_LH_X1%VSS_r16 N_VSS_M5_b x_PM_LS_LH_X1%VSS_43 0.138985
R_x_PM_LS_LH_X1%VSS_r17 x_PM_LS_LH_X1%VSS_34 x_PM_LS_LH_X1%VSS_47 0.0779847
R_x_PM_LS_LH_X1%VSS_r18 x_PM_LS_LH_X1%VSS_50 x_PM_LS_LH_X1%VSS_34 0.648235
R_x_PM_LS_LH_X1%VSS_r19 x_PM_LS_LH_X1%VSS_29 x_PM_LS_LH_X1%VSS_47 0.137064
R_x_PM_LS_LH_X1%VSS_r20 x_PM_LS_LH_X1%VSS_29 N_VSS_M9_s 0.646
R_x_PM_LS_LH_X1%VSS_r21 x_PM_LS_LH_X1%VSS_28 x_PM_LS_LH_X1%VSS_46 0.0731438
R_x_PM_LS_LH_X1%VSS_r22 x_PM_LS_LH_X1%VSS_27 x_PM_LS_LH_X1%VSS_47 0.0779847
R_x_PM_LS_LH_X1%VSS_r23 x_PM_LS_LH_X1%VSS_27 x_PM_LS_LH_X1%VSS_28 0.726471
R_x_PM_LS_LH_X1%VSS_r24 x_PM_LS_LH_X1%VSS_26 x_PM_LS_LH_X1%VSS_46 0.145286
R_x_PM_LS_LH_X1%VSS_r25 N_VSS_M7_d x_PM_LS_LH_X1%VSS_26 0.570339
R_x_PM_LS_LH_X1%VSS_r26 x_PM_LS_LH_X1%VSS_22 x_PM_LS_LH_X1%VSS_45 0.0731438
R_x_PM_LS_LH_X1%VSS_r27 x_PM_LS_LH_X1%VSS_22 VSS 0.860588
R_x_PM_LS_LH_X1%VSS_r28 x_PM_LS_LH_X1%VSS_21 x_PM_LS_LH_X1%VSS_46 0.0731438
R_x_PM_LS_LH_X1%VSS_r29 x_PM_LS_LH_X1%VSS_21 VSS 0.737647
R_x_PM_LS_LH_X1%VSS_r30 x_PM_LS_LH_X1%VSS_17 x_PM_LS_LH_X1%VSS_45 0.145286
R_x_PM_LS_LH_X1%VSS_r31 x_PM_LS_LH_X1%VSS_17 N_VSS_M5_d 0.692143
R_x_PM_LS_LH_X1%VSS_r32 N_VSS_M5_b x_PM_LS_LH_X1%VSS_16 0.138595
R_x_PM_LS_LH_X1%VSS_r33 x_PM_LS_LH_X1%VSS_15 x_PM_LS_LH_X1%VSS_45 0.0731438
R_x_PM_LS_LH_X1%VSS_r34 x_PM_LS_LH_X1%VSS_15 x_PM_LS_LH_X1%VSS_16 1.41941
R_x_PM_LS_LH_X1%VSS_r35 x_PM_LS_LH_X1%VSS_12 VSS 10.4276
R_x_PM_LS_LH_X1%VSS_r36 x_PM_LS_LH_X1%VSS_11 N_VSS_M5_b 0.140282
R_x_PM_LS_LH_X1%VSS_r37 x_PM_LS_LH_X1%VSS_43 x_PM_LS_LH_X1%VSS_11 7.68941
C_x_PM_LS_LH_X1%A_c0 A VSS 0.0316047f
C_x_PM_LS_LH_X1%A_c1 x_PM_LS_LH_X1%A_10 VSS 0.00432166f
C_x_PM_LS_LH_X1%A_c2 x_PM_LS_LH_X1%A_9 VSS 0.0296024f
C_x_PM_LS_LH_X1%A_c3 N_A_M0_g VSS 0.0364372f
C_x_PM_LS_LH_X1%A_c4 N_A_M5_g VSS 0.0444261f
R_x_PM_LS_LH_X1%A_r5 x_PM_LS_LH_X1%A_14 x_PM_LS_LH_X1%A_16 25.0012
R_x_PM_LS_LH_X1%A_r6 A x_PM_LS_LH_X1%A_14 0.00826087
R_x_PM_LS_LH_X1%A_r7 x_PM_LS_LH_X1%A_9 x_PM_LS_LH_X1%A_16 22.1
R_x_PM_LS_LH_X1%A_r8 x_PM_LS_LH_X1%A_9 x_PM_LS_LH_X1%A_10 0.043368
R_x_PM_LS_LH_X1%A_r9 x_PM_LS_LH_X1%A_5 x_PM_LS_LH_X1%A_10 4.56151
R_x_PM_LS_LH_X1%A_r10 x_PM_LS_LH_X1%A_5 N_A_M0_g 29.25
R_x_PM_LS_LH_X1%A_r11 x_PM_LS_LH_X1%A_1 x_PM_LS_LH_X1%A_10 4.56151
R_x_PM_LS_LH_X1%A_r12 x_PM_LS_LH_X1%A_1 N_A_M5_g 38.22
C_x_PM_LS_LH_X1%VDDL_c0 x_PM_LS_LH_X1%VDDL_16 VSS 0.0391221f
C_x_PM_LS_LH_X1%VDDL_c1 VDDL VSS 0.0311375f
C_x_PM_LS_LH_X1%VDDL_c2 N_VDDL_M0_d VSS 0.032101f
R_x_PM_LS_LH_X1%VDDL_r3 N_VDDL_M0_b x_PM_LS_LH_X1%VDDL_16 0.00475
R_x_PM_LS_LH_X1%VDDL_r4 VDDL N_VDDL_M0_b 0.00475
R_x_PM_LS_LH_X1%VDDL_r5 x_PM_LS_LH_X1%VDDL_7 x_PM_LS_LH_X1%VDDL_16 0.095
R_x_PM_LS_LH_X1%VDDL_r6 x_PM_LS_LH_X1%VDDL_7 N_VDDL_M0_d 0.963571
C_x_PM_LS_LH_X1%5_c0 x_PM_LS_LH_X1%5_29 VSS 0.00210188f
C_x_PM_LS_LH_X1%5_c1 x_PM_LS_LH_X1%5_26 VSS 0.0700745f
C_x_PM_LS_LH_X1%5_c2 N_5_M0_s VSS 0.0552907f
C_x_PM_LS_LH_X1%5_c3 x_PM_LS_LH_X1%5_19 VSS 0.0380396f
C_x_PM_LS_LH_X1%5_c4 x_PM_LS_LH_X1%5_15 VSS 0.0746028f
C_x_PM_LS_LH_X1%5_c5 x_PM_LS_LH_X1%5_14 VSS 0.00312566f
C_x_PM_LS_LH_X1%5_c6 N_5_M7_g VSS 0.0260798f
C_x_PM_LS_LH_X1%5_c7 N_5_M1_g VSS 0.0429392f
C_x_PM_LS_LH_X1%5_c8 N_5_M6_g VSS 0.0258872f
R_x_PM_LS_LH_X1%5_r9 x_PM_LS_LH_X1%5_26 x_PM_LS_LH_X1%5_30 25.0012
R_x_PM_LS_LH_X1%5_r10 x_PM_LS_LH_X1%5_24 x_PM_LS_LH_X1%5_29 0.0418175
R_x_PM_LS_LH_X1%5_r11 x_PM_LS_LH_X1%5_24 x_PM_LS_LH_X1%5_26 2.375
R_x_PM_LS_LH_X1%5_r12 x_PM_LS_LH_X1%5_20 x_PM_LS_LH_X1%5_29 0.160909
R_x_PM_LS_LH_X1%5_r13 x_PM_LS_LH_X1%5_20 N_5_M0_s 1.53357
R_x_PM_LS_LH_X1%5_r14 x_PM_LS_LH_X1%5_19 x_PM_LS_LH_X1%5_29 0.160909
R_x_PM_LS_LH_X1%5_r15 N_5_M5_s x_PM_LS_LH_X1%5_19 0.543196
R_x_PM_LS_LH_X1%5_r16 x_PM_LS_LH_X1%5_15 x_PM_LS_LH_X1%5_30 40.3
R_x_PM_LS_LH_X1%5_r17 x_PM_LS_LH_X1%5_13 x_PM_LS_LH_X1%5_30 16.9
R_x_PM_LS_LH_X1%5_r18 x_PM_LS_LH_X1%5_13 x_PM_LS_LH_X1%5_14 0.043368
R_x_PM_LS_LH_X1%5_r19 x_PM_LS_LH_X1%5_9 x_PM_LS_LH_X1%5_15 4.58872
R_x_PM_LS_LH_X1%5_r20 x_PM_LS_LH_X1%5_9 N_5_M7_g 17.94
R_x_PM_LS_LH_X1%5_r21 x_PM_LS_LH_X1%5_5 x_PM_LS_LH_X1%5_14 4.56151
R_x_PM_LS_LH_X1%5_r22 x_PM_LS_LH_X1%5_5 N_5_M1_g 46.41
R_x_PM_LS_LH_X1%5_r23 x_PM_LS_LH_X1%5_1 x_PM_LS_LH_X1%5_14 4.56151
R_x_PM_LS_LH_X1%5_r24 x_PM_LS_LH_X1%5_1 N_5_M6_g 21.06
C_x_PM_LS_LH_X1%6_c0 x_PM_LS_LH_X1%6_25 VSS 0.00303231f
C_x_PM_LS_LH_X1%6_c1 x_PM_LS_LH_X1%6_22 VSS 0.0573438f
C_x_PM_LS_LH_X1%6_c2 x_PM_LS_LH_X1%6_19 VSS 0.00563661f
C_x_PM_LS_LH_X1%6_c3 x_PM_LS_LH_X1%6_17 VSS 0.0557697f
C_x_PM_LS_LH_X1%6_c4 x_PM_LS_LH_X1%6_12 VSS 0.0902906f
C_x_PM_LS_LH_X1%6_c5 x_PM_LS_LH_X1%6_8 VSS 0.0455913f
C_x_PM_LS_LH_X1%6_c6 x_PM_LS_LH_X1%6_5 VSS 0.0409278f
C_x_PM_LS_LH_X1%6_c7 N_6_M8_g VSS 0.0457379f
R_x_PM_LS_LH_X1%6_r8 x_PM_LS_LH_X1%6_22 x_PM_LS_LH_X1%6_26 25.0012
R_x_PM_LS_LH_X1%6_r9 x_PM_LS_LH_X1%6_20 x_PM_LS_LH_X1%6_25 0.0418175
R_x_PM_LS_LH_X1%6_r10 x_PM_LS_LH_X1%6_20 x_PM_LS_LH_X1%6_22 0.963571
R_x_PM_LS_LH_X1%6_r11 x_PM_LS_LH_X1%6_18 x_PM_LS_LH_X1%6_25 0.160909
R_x_PM_LS_LH_X1%6_r12 x_PM_LS_LH_X1%6_18 x_PM_LS_LH_X1%6_19 0.515714
R_x_PM_LS_LH_X1%6_r13 x_PM_LS_LH_X1%6_17 x_PM_LS_LH_X1%6_25 0.160909
R_x_PM_LS_LH_X1%6_r14 x_PM_LS_LH_X1%6_16 x_PM_LS_LH_X1%6_17 1.33
R_x_PM_LS_LH_X1%6_r15 x_PM_LS_LH_X1%6_12 x_PM_LS_LH_X1%6_16 0.212317
R_x_PM_LS_LH_X1%6_r16 x_PM_LS_LH_X1%6_12 N_6_M6_d 1.20786
R_x_PM_LS_LH_X1%6_r17 x_PM_LS_LH_X1%6_8 x_PM_LS_LH_X1%6_19 0.212317
R_x_PM_LS_LH_X1%6_r18 x_PM_LS_LH_X1%6_8 N_6_M1_d 1.28929
R_x_PM_LS_LH_X1%6_r19 x_PM_LS_LH_X1%6_5 x_PM_LS_LH_X1%6_26 19.5
R_x_PM_LS_LH_X1%6_r20 x_PM_LS_LH_X1%6_1 x_PM_LS_LH_X1%6_5 4.58872
R_x_PM_LS_LH_X1%6_r21 x_PM_LS_LH_X1%6_1 N_6_M8_g 41.34
C_x_PM_LS_LH_X1%7_c0 x_PM_LS_LH_X1%7_25 VSS 0.0177579f
C_x_PM_LS_LH_X1%7_c1 x_PM_LS_LH_X1%7_20 VSS 0.113933f
C_x_PM_LS_LH_X1%7_c2 x_PM_LS_LH_X1%7_18 VSS 0.0176078f
C_x_PM_LS_LH_X1%7_c3 x_PM_LS_LH_X1%7_17 VSS 0.024488f
C_x_PM_LS_LH_X1%7_c4 x_PM_LS_LH_X1%7_16 VSS 0.0329139f
C_x_PM_LS_LH_X1%7_c5 x_PM_LS_LH_X1%7_15 VSS 0.0565612f
C_x_PM_LS_LH_X1%7_c6 N_7_M2_s VSS 0.0616349f
C_x_PM_LS_LH_X1%7_c7 N_7_M7_s VSS 0.0541196f
C_x_PM_LS_LH_X1%7_c8 N_7_M3_g VSS 0.0591782f
R_x_PM_LS_LH_X1%7_r9 x_PM_LS_LH_X1%7_22 x_PM_LS_LH_X1%7_25 7.54
R_x_PM_LS_LH_X1%7_r10 x_PM_LS_LH_X1%7_21 x_PM_LS_LH_X1%7_22 25.0012
R_x_PM_LS_LH_X1%7_r11 x_PM_LS_LH_X1%7_20 x_PM_LS_LH_X1%7_21 0.197151
R_x_PM_LS_LH_X1%7_r12 x_PM_LS_LH_X1%7_19 x_PM_LS_LH_X1%7_20 1.43857
R_x_PM_LS_LH_X1%7_r13 x_PM_LS_LH_X1%7_17 x_PM_LS_LH_X1%7_21 0.0151655
R_x_PM_LS_LH_X1%7_r14 x_PM_LS_LH_X1%7_17 x_PM_LS_LH_X1%7_18 0.95
R_x_PM_LS_LH_X1%7_r15 x_PM_LS_LH_X1%7_15 x_PM_LS_LH_X1%7_19 0.212317
R_x_PM_LS_LH_X1%7_r16 x_PM_LS_LH_X1%7_15 x_PM_LS_LH_X1%7_16 0.95
R_x_PM_LS_LH_X1%7_r17 x_PM_LS_LH_X1%7_11 x_PM_LS_LH_X1%7_18 0.212317
R_x_PM_LS_LH_X1%7_r18 x_PM_LS_LH_X1%7_11 N_7_M2_s 1.96786
R_x_PM_LS_LH_X1%7_r19 x_PM_LS_LH_X1%7_7 x_PM_LS_LH_X1%7_16 0.212317
R_x_PM_LS_LH_X1%7_r20 x_PM_LS_LH_X1%7_7 N_7_M7_s 0.665
R_x_PM_LS_LH_X1%7_r21 x_PM_LS_LH_X1%7_1 x_PM_LS_LH_X1%7_25 1.95
R_x_PM_LS_LH_X1%7_r22 x_PM_LS_LH_X1%7_1 N_7_M3_g 56.55
C_x_PM_LS_LH_X1%8_c0 x_PM_LS_LH_X1%8_39 VSS 0.0110499f
C_x_PM_LS_LH_X1%8_c1 x_PM_LS_LH_X1%8_32 VSS 0.00573998f
C_x_PM_LS_LH_X1%8_c2 x_PM_LS_LH_X1%8_31 VSS 0.033752f
C_x_PM_LS_LH_X1%8_c3 x_PM_LS_LH_X1%8_30 VSS 0.0480298f
C_x_PM_LS_LH_X1%8_c4 N_8_M3_d VSS 0.0312795f
C_x_PM_LS_LH_X1%8_c5 x_PM_LS_LH_X1%8_23 VSS 0.0514243f
C_x_PM_LS_LH_X1%8_c6 N_8_M8_d VSS 0.0501787f
C_x_PM_LS_LH_X1%8_c7 x_PM_LS_LH_X1%8_17 VSS 0.0790728f
C_x_PM_LS_LH_X1%8_c8 x_PM_LS_LH_X1%8_16 VSS 0.0153772f
C_x_PM_LS_LH_X1%8_c9 N_8_M4_g VSS 0.0832633f
C_x_PM_LS_LH_X1%8_c10 N_8_M9_g VSS 0.038414f
C_x_PM_LS_LH_X1%8_c11 N_8_M2_g VSS 0.0359457f
R_x_PM_LS_LH_X1%8_r12 x_PM_LS_LH_X1%8_37 x_PM_LS_LH_X1%8_39 4.42
R_x_PM_LS_LH_X1%8_r13 x_PM_LS_LH_X1%8_30 x_PM_LS_LH_X1%8_31 0.0272847
R_x_PM_LS_LH_X1%8_r14 x_PM_LS_LH_X1%8_28 x_PM_LS_LH_X1%8_30 0.558398
R_x_PM_LS_LH_X1%8_r15 x_PM_LS_LH_X1%8_28 x_PM_LS_LH_X1%8_37 25.0012
R_x_PM_LS_LH_X1%8_r16 x_PM_LS_LH_X1%8_24 x_PM_LS_LH_X1%8_32 0.266978
R_x_PM_LS_LH_X1%8_r17 x_PM_LS_LH_X1%8_24 N_8_M3_d 0.773571
R_x_PM_LS_LH_X1%8_r18 x_PM_LS_LH_X1%8_23 x_PM_LS_LH_X1%8_32 0.266978
R_x_PM_LS_LH_X1%8_r19 x_PM_LS_LH_X1%8_22 x_PM_LS_LH_X1%8_31 0.266978
R_x_PM_LS_LH_X1%8_r20 x_PM_LS_LH_X1%8_22 x_PM_LS_LH_X1%8_23 1.62857
R_x_PM_LS_LH_X1%8_r21 x_PM_LS_LH_X1%8_18 x_PM_LS_LH_X1%8_31 0.266978
R_x_PM_LS_LH_X1%8_r22 x_PM_LS_LH_X1%8_18 N_8_M8_d 0.909286
R_x_PM_LS_LH_X1%8_r23 x_PM_LS_LH_X1%8_17 x_PM_LS_LH_X1%8_32 0.0272847
R_x_PM_LS_LH_X1%8_r24 x_PM_LS_LH_X1%8_33 x_PM_LS_LH_X1%8_16 3.9
R_x_PM_LS_LH_X1%8_r25 x_PM_LS_LH_X1%8_15 x_PM_LS_LH_X1%8_17 0.53025
R_x_PM_LS_LH_X1%8_r26 x_PM_LS_LH_X1%8_15 x_PM_LS_LH_X1%8_16 25.0012
R_x_PM_LS_LH_X1%8_r27 x_PM_LS_LH_X1%8_9 x_PM_LS_LH_X1%8_39 1.95
R_x_PM_LS_LH_X1%8_r28 x_PM_LS_LH_X1%8_9 N_8_M4_g 96.72
R_x_PM_LS_LH_X1%8_r29 x_PM_LS_LH_X1%8_5 x_PM_LS_LH_X1%8_39 1.95
R_x_PM_LS_LH_X1%8_r30 x_PM_LS_LH_X1%8_5 N_8_M9_g 31.2
R_x_PM_LS_LH_X1%8_r31 x_PM_LS_LH_X1%8_1 x_PM_LS_LH_X1%8_33 1.95
R_x_PM_LS_LH_X1%8_r32 x_PM_LS_LH_X1%8_1 N_8_M2_g 27.69
C_x_PM_LS_LH_X1%Z_c0 N_Z_M9_d VSS 0.104777f
R_x_PM_LS_LH_X1%Z_r1 Z N_Z_M4_d 2.375
R_x_PM_LS_LH_X1%Z_r2 N_Z_M9_d Z 2.02214
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_LH_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LH_X2 VDD VSS A VDDL Z
*.PININFO VDD:P VDDL:P VSS:G A:I Z:O
*.EQN Z=A
M_M5 N_VDDL_M0_d N_A_M0_g N_5_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M6 N_6_M1_d N_5_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M7 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M8 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M9 N_Z_M4_d N_8_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=2.7e-07
M_M0 N_VSS_M5_d N_A_M5_g N_5_M5_s N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M6_d N_5_M6_g N_VSS_M5_d N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M2 N_VSS_M7_d N_5_M7_g N_7_M7_s N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_8_M8_d N_6_M8_g N_VSS_M7_d N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M4 N_Z_M9_d N_8_M9_g N_VSS_M9_s N_VSS_M5_b NMOS_VTL L=5e-08 W=1.8e-07
C_x_PM_LS_LH_X2%VDD_c0 x_PM_LS_LH_X2%VDD_43 VSS 0.0276945f
C_x_PM_LS_LH_X2%VDD_c1 x_PM_LS_LH_X2%VDD_40 VSS 0.00298886f
C_x_PM_LS_LH_X2%VDD_c2 x_PM_LS_LH_X2%VDD_39 VSS 0.00295509f
C_x_PM_LS_LH_X2%VDD_c3 x_PM_LS_LH_X2%VDD_38 VSS 0.0108319f
C_x_PM_LS_LH_X2%VDD_c4 x_PM_LS_LH_X2%VDD_37 VSS 0.2334f
C_x_PM_LS_LH_X2%VDD_c5 x_PM_LS_LH_X2%VDD_28 VSS 0.261469f
C_x_PM_LS_LH_X2%VDD_c6 N_VDD_M4_s VSS 0.0511018f
C_x_PM_LS_LH_X2%VDD_c7 x_PM_LS_LH_X2%VDD_20 VSS 0.0215833f
C_x_PM_LS_LH_X2%VDD_c8 N_VDD_M2_d VSS 0.034153f
C_x_PM_LS_LH_X2%VDD_c9 x_PM_LS_LH_X2%VDD_14 VSS 0.119458f
C_x_PM_LS_LH_X2%VDD_c10 x_PM_LS_LH_X2%VDD_13 VSS 0.0192462f
C_x_PM_LS_LH_X2%VDD_c11 x_PM_LS_LH_X2%VDD_9 VSS 0.667932f
R_x_PM_LS_LH_X2%VDD_r12 N_VDD_M2_b x_PM_LS_LH_X2%VDD_43 0.13879
R_x_PM_LS_LH_X2%VDD_r13 N_VDD_M2_b x_PM_LS_LH_X2%VDD_38 0.138595
R_x_PM_LS_LH_X2%VDD_r14 N_VDD_M2_b x_PM_LS_LH_X2%VDD_37 0.138985
R_x_PM_LS_LH_X2%VDD_r15 N_VDD_M2_b x_PM_LS_LH_X2%VDD_28 0.13879
R_x_PM_LS_LH_X2%VDD_r16 x_PM_LS_LH_X2%VDD_28 VDD 3.84471
R_x_PM_LS_LH_X2%VDD_r17 x_PM_LS_LH_X2%VDD_27 x_PM_LS_LH_X2%VDD_40 0.0731438
R_x_PM_LS_LH_X2%VDD_r18 x_PM_LS_LH_X2%VDD_43 x_PM_LS_LH_X2%VDD_27 0.659412
R_x_PM_LS_LH_X2%VDD_r19 x_PM_LS_LH_X2%VDD_22 x_PM_LS_LH_X2%VDD_40 0.145286
R_x_PM_LS_LH_X2%VDD_r20 x_PM_LS_LH_X2%VDD_22 N_VDD_M4_s 0.665
R_x_PM_LS_LH_X2%VDD_r21 x_PM_LS_LH_X2%VDD_21 x_PM_LS_LH_X2%VDD_39 0.0731438
R_x_PM_LS_LH_X2%VDD_r22 x_PM_LS_LH_X2%VDD_20 x_PM_LS_LH_X2%VDD_40 0.0731438
R_x_PM_LS_LH_X2%VDD_r23 x_PM_LS_LH_X2%VDD_20 x_PM_LS_LH_X2%VDD_21 0.648235
R_x_PM_LS_LH_X2%VDD_r24 x_PM_LS_LH_X2%VDD_16 x_PM_LS_LH_X2%VDD_39 0.145286
R_x_PM_LS_LH_X2%VDD_r25 x_PM_LS_LH_X2%VDD_16 N_VDD_M2_d 0.882143
R_x_PM_LS_LH_X2%VDD_r26 x_PM_LS_LH_X2%VDD_14 x_PM_LS_LH_X2%VDD_39 0.0731438
R_x_PM_LS_LH_X2%VDD_r27 x_PM_LS_LH_X2%VDD_14 x_PM_LS_LH_X2%VDD_38 3.25235
R_x_PM_LS_LH_X2%VDD_r28 x_PM_LS_LH_X2%VDD_13 N_VDD_M2_b 0.140282
R_x_PM_LS_LH_X2%VDD_r29 x_PM_LS_LH_X2%VDD_37 x_PM_LS_LH_X2%VDD_13 7.68941
R_x_PM_LS_LH_X2%VDD_r30 x_PM_LS_LH_X2%VDD_9 VDD 10.4276
C_x_PM_LS_LH_X2%VSS_c0 x_PM_LS_LH_X2%VSS_52 VSS 0.0256329f
C_x_PM_LS_LH_X2%VSS_c1 x_PM_LS_LH_X2%VSS_49 VSS 0.0029415f
C_x_PM_LS_LH_X2%VSS_c2 x_PM_LS_LH_X2%VSS_48 VSS 0.00293947f
C_x_PM_LS_LH_X2%VSS_c3 x_PM_LS_LH_X2%VSS_47 VSS 0.00564012f
C_x_PM_LS_LH_X2%VSS_c4 x_PM_LS_LH_X2%VSS_45 VSS 0.2334f
C_x_PM_LS_LH_X2%VSS_c5 N_VSS_M5_b VSS 0.261469f
C_x_PM_LS_LH_X2%VSS_c6 N_VSS_M9_s VSS 0.0307984f
C_x_PM_LS_LH_X2%VSS_c7 x_PM_LS_LH_X2%VSS_29 VSS 0.0279486f
C_x_PM_LS_LH_X2%VSS_c8 N_VSS_M7_d VSS 0.0390406f
C_x_PM_LS_LH_X2%VSS_c9 x_PM_LS_LH_X2%VSS_21 VSS 0.0959234f
C_x_PM_LS_LH_X2%VSS_c10 N_VSS_M5_d VSS 0.0502719f
C_x_PM_LS_LH_X2%VSS_c11 x_PM_LS_LH_X2%VSS_16 VSS 0.0106114f
C_x_PM_LS_LH_X2%VSS_c12 x_PM_LS_LH_X2%VSS_15 VSS 0.0577389f
C_x_PM_LS_LH_X2%VSS_c13 x_PM_LS_LH_X2%VSS_12 VSS 0.667932f
C_x_PM_LS_LH_X2%VSS_c14 x_PM_LS_LH_X2%VSS_11 VSS 0.0192462f
R_x_PM_LS_LH_X2%VSS_r15 N_VSS_M5_b x_PM_LS_LH_X2%VSS_52 0.13879
R_x_PM_LS_LH_X2%VSS_r16 N_VSS_M5_b x_PM_LS_LH_X2%VSS_45 0.138985
R_x_PM_LS_LH_X2%VSS_r17 x_PM_LS_LH_X2%VSS_36 x_PM_LS_LH_X2%VSS_49 0.0731438
R_x_PM_LS_LH_X2%VSS_r18 x_PM_LS_LH_X2%VSS_52 x_PM_LS_LH_X2%VSS_36 0.659412
R_x_PM_LS_LH_X2%VSS_r19 x_PM_LS_LH_X2%VSS_31 x_PM_LS_LH_X2%VSS_49 0.145286
R_x_PM_LS_LH_X2%VSS_r20 x_PM_LS_LH_X2%VSS_31 N_VSS_M9_s 0.692143
R_x_PM_LS_LH_X2%VSS_r21 x_PM_LS_LH_X2%VSS_30 x_PM_LS_LH_X2%VSS_48 0.0731438
R_x_PM_LS_LH_X2%VSS_r22 x_PM_LS_LH_X2%VSS_29 x_PM_LS_LH_X2%VSS_49 0.0731438
R_x_PM_LS_LH_X2%VSS_r23 x_PM_LS_LH_X2%VSS_29 x_PM_LS_LH_X2%VSS_30 0.637059
R_x_PM_LS_LH_X2%VSS_r24 x_PM_LS_LH_X2%VSS_25 x_PM_LS_LH_X2%VSS_48 0.145286
R_x_PM_LS_LH_X2%VSS_r25 x_PM_LS_LH_X2%VSS_25 N_VSS_M7_d 0.665
R_x_PM_LS_LH_X2%VSS_r26 x_PM_LS_LH_X2%VSS_22 x_PM_LS_LH_X2%VSS_47 0.132285
R_x_PM_LS_LH_X2%VSS_r27 x_PM_LS_LH_X2%VSS_22 VSS 0.771176
R_x_PM_LS_LH_X2%VSS_r28 x_PM_LS_LH_X2%VSS_21 x_PM_LS_LH_X2%VSS_48 0.0731438
R_x_PM_LS_LH_X2%VSS_r29 x_PM_LS_LH_X2%VSS_21 VSS 0.827059
R_x_PM_LS_LH_X2%VSS_r30 x_PM_LS_LH_X2%VSS_17 x_PM_LS_LH_X2%VSS_47 0.0680382
R_x_PM_LS_LH_X2%VSS_r31 x_PM_LS_LH_X2%VSS_17 N_VSS_M5_d 0.344815
R_x_PM_LS_LH_X2%VSS_r32 N_VSS_M5_b x_PM_LS_LH_X2%VSS_16 0.138595
R_x_PM_LS_LH_X2%VSS_r33 x_PM_LS_LH_X2%VSS_15 x_PM_LS_LH_X2%VSS_47 0.132285
R_x_PM_LS_LH_X2%VSS_r34 x_PM_LS_LH_X2%VSS_15 x_PM_LS_LH_X2%VSS_16 1.36353
R_x_PM_LS_LH_X2%VSS_r35 x_PM_LS_LH_X2%VSS_12 VSS 10.4276
R_x_PM_LS_LH_X2%VSS_r36 x_PM_LS_LH_X2%VSS_11 N_VSS_M5_b 0.140282
R_x_PM_LS_LH_X2%VSS_r37 x_PM_LS_LH_X2%VSS_45 x_PM_LS_LH_X2%VSS_11 7.68941
C_x_PM_LS_LH_X2%A_c0 A VSS 0.0304102f
C_x_PM_LS_LH_X2%A_c1 x_PM_LS_LH_X2%A_10 VSS 0.00417485f
C_x_PM_LS_LH_X2%A_c2 x_PM_LS_LH_X2%A_9 VSS 0.0301473f
C_x_PM_LS_LH_X2%A_c3 N_A_M0_g VSS 0.0354645f
C_x_PM_LS_LH_X2%A_c4 N_A_M5_g VSS 0.0428618f
R_x_PM_LS_LH_X2%A_r5 x_PM_LS_LH_X2%A_14 x_PM_LS_LH_X2%A_16 25.0012
R_x_PM_LS_LH_X2%A_r6 A x_PM_LS_LH_X2%A_14 0.00904762
R_x_PM_LS_LH_X2%A_r7 x_PM_LS_LH_X2%A_9 x_PM_LS_LH_X2%A_16 22.62
R_x_PM_LS_LH_X2%A_r8 x_PM_LS_LH_X2%A_9 x_PM_LS_LH_X2%A_10 0.043368
R_x_PM_LS_LH_X2%A_r9 x_PM_LS_LH_X2%A_5 x_PM_LS_LH_X2%A_10 4.56151
R_x_PM_LS_LH_X2%A_r10 x_PM_LS_LH_X2%A_5 N_A_M0_g 28.86
R_x_PM_LS_LH_X2%A_r11 x_PM_LS_LH_X2%A_1 x_PM_LS_LH_X2%A_10 4.56151
R_x_PM_LS_LH_X2%A_r12 x_PM_LS_LH_X2%A_1 N_A_M5_g 37.44
C_x_PM_LS_LH_X2%VDDL_c0 VDDL VSS 0.0711981f
C_x_PM_LS_LH_X2%VDDL_c1 x_PM_LS_LH_X2%VDDL_6 VSS 0.0364982f
R_x_PM_LS_LH_X2%VDDL_r2 N_VDDL_M0_b VDDL 0.13775
R_x_PM_LS_LH_X2%VDDL_r3 x_PM_LS_LH_X2%VDDL_6 N_VDDL_M0_b 0.095
R_x_PM_LS_LH_X2%VDDL_r4 N_VDDL_M0_d x_PM_LS_LH_X2%VDDL_6 0.459879
C_x_PM_LS_LH_X2%5_c0 x_PM_LS_LH_X2%5_31 VSS 0.00215795f
C_x_PM_LS_LH_X2%5_c1 x_PM_LS_LH_X2%5_28 VSS 0.0846961f
C_x_PM_LS_LH_X2%5_c2 N_5_M0_s VSS 0.0566569f
C_x_PM_LS_LH_X2%5_c3 N_5_M5_s VSS 0.0364537f
C_x_PM_LS_LH_X2%5_c4 x_PM_LS_LH_X2%5_15 VSS 0.0761368f
C_x_PM_LS_LH_X2%5_c5 x_PM_LS_LH_X2%5_14 VSS 0.00296759f
C_x_PM_LS_LH_X2%5_c6 N_5_M7_g VSS 0.0259996f
C_x_PM_LS_LH_X2%5_c7 N_5_M1_g VSS 0.0436645f
C_x_PM_LS_LH_X2%5_c8 N_5_M6_g VSS 0.0225716f
R_x_PM_LS_LH_X2%5_r9 x_PM_LS_LH_X2%5_28 x_PM_LS_LH_X2%5_32 25.0012
R_x_PM_LS_LH_X2%5_r10 x_PM_LS_LH_X2%5_26 x_PM_LS_LH_X2%5_31 0.0418175
R_x_PM_LS_LH_X2%5_r11 x_PM_LS_LH_X2%5_26 x_PM_LS_LH_X2%5_28 2.59214
R_x_PM_LS_LH_X2%5_r12 x_PM_LS_LH_X2%5_22 x_PM_LS_LH_X2%5_31 0.160909
R_x_PM_LS_LH_X2%5_r13 x_PM_LS_LH_X2%5_22 N_5_M0_s 1.64214
R_x_PM_LS_LH_X2%5_r14 x_PM_LS_LH_X2%5_18 x_PM_LS_LH_X2%5_31 0.160909
R_x_PM_LS_LH_X2%5_r15 x_PM_LS_LH_X2%5_18 N_5_M5_s 0.610714
R_x_PM_LS_LH_X2%5_r16 x_PM_LS_LH_X2%5_15 x_PM_LS_LH_X2%5_32 40.3
R_x_PM_LS_LH_X2%5_r17 x_PM_LS_LH_X2%5_13 x_PM_LS_LH_X2%5_32 18.98
R_x_PM_LS_LH_X2%5_r18 x_PM_LS_LH_X2%5_13 x_PM_LS_LH_X2%5_14 0.043368
R_x_PM_LS_LH_X2%5_r19 x_PM_LS_LH_X2%5_9 x_PM_LS_LH_X2%5_15 4.58872
R_x_PM_LS_LH_X2%5_r20 x_PM_LS_LH_X2%5_9 N_5_M7_g 17.94
R_x_PM_LS_LH_X2%5_r21 x_PM_LS_LH_X2%5_5 x_PM_LS_LH_X2%5_14 4.56151
R_x_PM_LS_LH_X2%5_r22 x_PM_LS_LH_X2%5_5 N_5_M1_g 48.36
R_x_PM_LS_LH_X2%5_r23 x_PM_LS_LH_X2%5_1 x_PM_LS_LH_X2%5_14 4.56151
R_x_PM_LS_LH_X2%5_r24 x_PM_LS_LH_X2%5_1 N_5_M6_g 17.94
C_x_PM_LS_LH_X2%6_c0 x_PM_LS_LH_X2%6_25 VSS 0.00304754f
C_x_PM_LS_LH_X2%6_c1 x_PM_LS_LH_X2%6_22 VSS 0.0492466f
C_x_PM_LS_LH_X2%6_c2 x_PM_LS_LH_X2%6_19 VSS 0.0046153f
C_x_PM_LS_LH_X2%6_c3 x_PM_LS_LH_X2%6_17 VSS 0.0535124f
C_x_PM_LS_LH_X2%6_c4 x_PM_LS_LH_X2%6_12 VSS 0.0442445f
C_x_PM_LS_LH_X2%6_c5 x_PM_LS_LH_X2%6_8 VSS 0.107629f
C_x_PM_LS_LH_X2%6_c6 x_PM_LS_LH_X2%6_5 VSS 0.0404062f
C_x_PM_LS_LH_X2%6_c7 N_6_M8_g VSS 0.049249f
R_x_PM_LS_LH_X2%6_r8 x_PM_LS_LH_X2%6_22 x_PM_LS_LH_X2%6_26 25.0012
R_x_PM_LS_LH_X2%6_r9 x_PM_LS_LH_X2%6_20 x_PM_LS_LH_X2%6_25 0.0418175
R_x_PM_LS_LH_X2%6_r10 x_PM_LS_LH_X2%6_20 x_PM_LS_LH_X2%6_22 0.963571
R_x_PM_LS_LH_X2%6_r11 x_PM_LS_LH_X2%6_18 x_PM_LS_LH_X2%6_25 0.160909
R_x_PM_LS_LH_X2%6_r12 x_PM_LS_LH_X2%6_18 x_PM_LS_LH_X2%6_19 0.434286
R_x_PM_LS_LH_X2%6_r13 x_PM_LS_LH_X2%6_17 x_PM_LS_LH_X2%6_25 0.160909
R_x_PM_LS_LH_X2%6_r14 x_PM_LS_LH_X2%6_16 x_PM_LS_LH_X2%6_17 1.41143
R_x_PM_LS_LH_X2%6_r15 x_PM_LS_LH_X2%6_12 x_PM_LS_LH_X2%6_19 0.212317
R_x_PM_LS_LH_X2%6_r16 x_PM_LS_LH_X2%6_12 N_6_M1_d 1.34357
R_x_PM_LS_LH_X2%6_r17 x_PM_LS_LH_X2%6_8 x_PM_LS_LH_X2%6_16 0.212317
R_x_PM_LS_LH_X2%6_r18 x_PM_LS_LH_X2%6_8 N_6_M6_d 1.34357
R_x_PM_LS_LH_X2%6_r19 x_PM_LS_LH_X2%6_5 x_PM_LS_LH_X2%6_26 20.02
R_x_PM_LS_LH_X2%6_r20 x_PM_LS_LH_X2%6_1 x_PM_LS_LH_X2%6_5 4.58872
R_x_PM_LS_LH_X2%6_r21 x_PM_LS_LH_X2%6_1 N_6_M8_g 46.02
C_x_PM_LS_LH_X2%7_c0 x_PM_LS_LH_X2%7_25 VSS 0.0159951f
C_x_PM_LS_LH_X2%7_c1 x_PM_LS_LH_X2%7_20 VSS 0.110561f
C_x_PM_LS_LH_X2%7_c2 x_PM_LS_LH_X2%7_18 VSS 0.0167719f
C_x_PM_LS_LH_X2%7_c3 x_PM_LS_LH_X2%7_17 VSS 0.0264715f
C_x_PM_LS_LH_X2%7_c4 x_PM_LS_LH_X2%7_16 VSS 0.0265593f
C_x_PM_LS_LH_X2%7_c5 x_PM_LS_LH_X2%7_15 VSS 0.0480174f
C_x_PM_LS_LH_X2%7_c6 N_7_M2_s VSS 0.0609392f
C_x_PM_LS_LH_X2%7_c7 N_7_M7_s VSS 0.0528153f
C_x_PM_LS_LH_X2%7_c8 N_7_M3_g VSS 0.0616322f
R_x_PM_LS_LH_X2%7_r9 x_PM_LS_LH_X2%7_22 x_PM_LS_LH_X2%7_25 4.42
R_x_PM_LS_LH_X2%7_r10 x_PM_LS_LH_X2%7_21 x_PM_LS_LH_X2%7_22 25.0012
R_x_PM_LS_LH_X2%7_r11 x_PM_LS_LH_X2%7_20 x_PM_LS_LH_X2%7_21 0.0141545
R_x_PM_LS_LH_X2%7_r12 x_PM_LS_LH_X2%7_19 x_PM_LS_LH_X2%7_20 1.52
R_x_PM_LS_LH_X2%7_r13 x_PM_LS_LH_X2%7_17 x_PM_LS_LH_X2%7_21 0.198162
R_x_PM_LS_LH_X2%7_r14 x_PM_LS_LH_X2%7_17 x_PM_LS_LH_X2%7_18 0.922857
R_x_PM_LS_LH_X2%7_r15 x_PM_LS_LH_X2%7_15 x_PM_LS_LH_X2%7_19 0.212317
R_x_PM_LS_LH_X2%7_r16 x_PM_LS_LH_X2%7_15 x_PM_LS_LH_X2%7_16 0.922857
R_x_PM_LS_LH_X2%7_r17 x_PM_LS_LH_X2%7_11 x_PM_LS_LH_X2%7_18 0.212317
R_x_PM_LS_LH_X2%7_r18 x_PM_LS_LH_X2%7_11 N_7_M2_s 1.94071
R_x_PM_LS_LH_X2%7_r19 x_PM_LS_LH_X2%7_7 x_PM_LS_LH_X2%7_16 0.212317
R_x_PM_LS_LH_X2%7_r20 x_PM_LS_LH_X2%7_7 N_7_M7_s 0.665
R_x_PM_LS_LH_X2%7_r21 x_PM_LS_LH_X2%7_1 x_PM_LS_LH_X2%7_25 1.95
R_x_PM_LS_LH_X2%7_r22 x_PM_LS_LH_X2%7_1 N_7_M3_g 60.45
C_x_PM_LS_LH_X2%8_c0 x_PM_LS_LH_X2%8_39 VSS 0.0110788f
C_x_PM_LS_LH_X2%8_c1 x_PM_LS_LH_X2%8_32 VSS 0.00626338f
C_x_PM_LS_LH_X2%8_c2 x_PM_LS_LH_X2%8_31 VSS 0.0290577f
C_x_PM_LS_LH_X2%8_c3 x_PM_LS_LH_X2%8_30 VSS 0.0413946f
C_x_PM_LS_LH_X2%8_c4 N_8_M3_d VSS 0.0432583f
C_x_PM_LS_LH_X2%8_c5 x_PM_LS_LH_X2%8_23 VSS 0.0319117f
C_x_PM_LS_LH_X2%8_c6 N_8_M8_d VSS 0.0761636f
C_x_PM_LS_LH_X2%8_c7 x_PM_LS_LH_X2%8_17 VSS 0.0810228f
C_x_PM_LS_LH_X2%8_c8 x_PM_LS_LH_X2%8_16 VSS 0.015423f
C_x_PM_LS_LH_X2%8_c9 N_8_M4_g VSS 0.0813274f
C_x_PM_LS_LH_X2%8_c10 N_8_M9_g VSS 0.0473961f
C_x_PM_LS_LH_X2%8_c11 N_8_M2_g VSS 0.0359467f
R_x_PM_LS_LH_X2%8_r12 x_PM_LS_LH_X2%8_37 x_PM_LS_LH_X2%8_39 4.42
R_x_PM_LS_LH_X2%8_r13 x_PM_LS_LH_X2%8_30 x_PM_LS_LH_X2%8_31 0.0272847
R_x_PM_LS_LH_X2%8_r14 x_PM_LS_LH_X2%8_28 x_PM_LS_LH_X2%8_30 0.445805
R_x_PM_LS_LH_X2%8_r15 x_PM_LS_LH_X2%8_28 x_PM_LS_LH_X2%8_37 25.0012
R_x_PM_LS_LH_X2%8_r16 x_PM_LS_LH_X2%8_24 x_PM_LS_LH_X2%8_32 0.266978
R_x_PM_LS_LH_X2%8_r17 x_PM_LS_LH_X2%8_24 N_8_M3_d 0.773571
R_x_PM_LS_LH_X2%8_r18 x_PM_LS_LH_X2%8_23 x_PM_LS_LH_X2%8_32 0.266978
R_x_PM_LS_LH_X2%8_r19 x_PM_LS_LH_X2%8_22 x_PM_LS_LH_X2%8_31 0.266978
R_x_PM_LS_LH_X2%8_r20 x_PM_LS_LH_X2%8_22 x_PM_LS_LH_X2%8_23 1.14
R_x_PM_LS_LH_X2%8_r21 x_PM_LS_LH_X2%8_18 x_PM_LS_LH_X2%8_31 0.266978
R_x_PM_LS_LH_X2%8_r22 x_PM_LS_LH_X2%8_18 N_8_M8_d 1.47929
R_x_PM_LS_LH_X2%8_r23 x_PM_LS_LH_X2%8_17 x_PM_LS_LH_X2%8_32 0.0272847
R_x_PM_LS_LH_X2%8_r24 x_PM_LS_LH_X2%8_33 x_PM_LS_LH_X2%8_16 3.9
R_x_PM_LS_LH_X2%8_r25 x_PM_LS_LH_X2%8_15 x_PM_LS_LH_X2%8_17 0.53025
R_x_PM_LS_LH_X2%8_r26 x_PM_LS_LH_X2%8_15 x_PM_LS_LH_X2%8_16 25.0012
R_x_PM_LS_LH_X2%8_r27 x_PM_LS_LH_X2%8_9 x_PM_LS_LH_X2%8_39 1.95
R_x_PM_LS_LH_X2%8_r28 x_PM_LS_LH_X2%8_9 N_8_M4_g 77.22
R_x_PM_LS_LH_X2%8_r29 x_PM_LS_LH_X2%8_5 x_PM_LS_LH_X2%8_39 1.95
R_x_PM_LS_LH_X2%8_r30 x_PM_LS_LH_X2%8_5 N_8_M9_g 40.56
R_x_PM_LS_LH_X2%8_r31 x_PM_LS_LH_X2%8_1 x_PM_LS_LH_X2%8_33 1.95
R_x_PM_LS_LH_X2%8_r32 x_PM_LS_LH_X2%8_1 N_8_M2_g 27.69
C_x_PM_LS_LH_X2%Z_c0 N_Z_M9_d VSS 0.120579f
R_x_PM_LS_LH_X2%Z_r1 Z N_Z_M4_d 2.04929
R_x_PM_LS_LH_X2%Z_r2 N_Z_M9_d Z 2.64643
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LS_LH_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 14:44:41 on Tue, 4 Jan 2011.                                              *
*                                                                              *
********************************************************************************
.SUBCKT LS_LH_X4 VDD VSS A VDDL Z
*.PININFO VDD:P VDDL:P VSS:G A:I Z:O
*.EQN Z=A
M_M5 N_VDDL_M0_d N_A_M0_g N_5_M0_s N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M6 N_6_M1_d N_5_M1_g N_VDDL_M0_d N_VDDL_M0_b PMOS_VTL L=5e-08 W=1.3e-07
M_M7 N_VDD_M2_d N_8_M2_g N_7_M2_s N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M8 N_8_M3_d N_7_M3_g N_VDD_M2_d N_VDD_M2_b PMOS_VTL L=5e-08 W=1.35e-07
M_M9 N_Z_M4_d N_8_M4_g N_VDD_M4_s N_VDD_M2_b PMOS_VTL L=5e-08 W=5.4e-07
M_M0 N_VSS_M5_d N_A_M5_g N_5_M5_s N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M1 N_6_M6_d N_5_M6_g N_VSS_M5_d N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M2 N_VSS_M7_d N_5_M7_g N_7_M7_s N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M3 N_8_M8_d N_6_M8_g N_VSS_M7_d N_VSS_M5_b NMOS_VTL L=5e-08 W=9e-08
M_M4 N_Z_M9_d N_8_M9_g N_VSS_M9_s N_VSS_M5_b NMOS_VTL L=5e-08 W=3.3e-07
C_x_PM_LS_LH_X4%VDD_c0 x_PM_LS_LH_X4%VDD_43 VSS 0.0225187f
C_x_PM_LS_LH_X4%VDD_c1 x_PM_LS_LH_X4%VDD_40 VSS 0.00298886f
C_x_PM_LS_LH_X4%VDD_c2 x_PM_LS_LH_X4%VDD_39 VSS 0.00295509f
C_x_PM_LS_LH_X4%VDD_c3 x_PM_LS_LH_X4%VDD_38 VSS 0.0108319f
C_x_PM_LS_LH_X4%VDD_c4 x_PM_LS_LH_X4%VDD_37 VSS 0.2334f
C_x_PM_LS_LH_X4%VDD_c5 x_PM_LS_LH_X4%VDD_28 VSS 0.26152f
C_x_PM_LS_LH_X4%VDD_c6 N_VDD_M4_s VSS 0.0509066f
C_x_PM_LS_LH_X4%VDD_c7 x_PM_LS_LH_X4%VDD_20 VSS 0.02065f
C_x_PM_LS_LH_X4%VDD_c8 N_VDD_M2_d VSS 0.0381752f
C_x_PM_LS_LH_X4%VDD_c9 x_PM_LS_LH_X4%VDD_14 VSS 0.120237f
C_x_PM_LS_LH_X4%VDD_c10 x_PM_LS_LH_X4%VDD_13 VSS 0.0192462f
C_x_PM_LS_LH_X4%VDD_c11 x_PM_LS_LH_X4%VDD_9 VSS 0.667932f
R_x_PM_LS_LH_X4%VDD_r12 N_VDD_M2_b x_PM_LS_LH_X4%VDD_43 0.13879
R_x_PM_LS_LH_X4%VDD_r13 N_VDD_M2_b x_PM_LS_LH_X4%VDD_38 0.138595
R_x_PM_LS_LH_X4%VDD_r14 N_VDD_M2_b x_PM_LS_LH_X4%VDD_37 0.138985
R_x_PM_LS_LH_X4%VDD_r15 N_VDD_M2_b x_PM_LS_LH_X4%VDD_28 0.13879
R_x_PM_LS_LH_X4%VDD_r16 x_PM_LS_LH_X4%VDD_28 VDD 3.84471
R_x_PM_LS_LH_X4%VDD_r17 x_PM_LS_LH_X4%VDD_27 x_PM_LS_LH_X4%VDD_40 0.0731438
R_x_PM_LS_LH_X4%VDD_r18 x_PM_LS_LH_X4%VDD_43 x_PM_LS_LH_X4%VDD_27 0.670588
R_x_PM_LS_LH_X4%VDD_r19 x_PM_LS_LH_X4%VDD_22 x_PM_LS_LH_X4%VDD_40 0.145286
R_x_PM_LS_LH_X4%VDD_r20 x_PM_LS_LH_X4%VDD_22 N_VDD_M4_s 0.665
R_x_PM_LS_LH_X4%VDD_r21 x_PM_LS_LH_X4%VDD_21 x_PM_LS_LH_X4%VDD_39 0.0731438
R_x_PM_LS_LH_X4%VDD_r22 x_PM_LS_LH_X4%VDD_20 x_PM_LS_LH_X4%VDD_40 0.0731438
R_x_PM_LS_LH_X4%VDD_r23 x_PM_LS_LH_X4%VDD_20 x_PM_LS_LH_X4%VDD_21 0.614706
R_x_PM_LS_LH_X4%VDD_r24 x_PM_LS_LH_X4%VDD_16 x_PM_LS_LH_X4%VDD_39 0.145286
R_x_PM_LS_LH_X4%VDD_r25 x_PM_LS_LH_X4%VDD_16 N_VDD_M2_d 0.882143
R_x_PM_LS_LH_X4%VDD_r26 x_PM_LS_LH_X4%VDD_14 x_PM_LS_LH_X4%VDD_39 0.0731438
R_x_PM_LS_LH_X4%VDD_r27 x_PM_LS_LH_X4%VDD_14 x_PM_LS_LH_X4%VDD_38 3.27471
R_x_PM_LS_LH_X4%VDD_r28 x_PM_LS_LH_X4%VDD_13 N_VDD_M2_b 0.140282
R_x_PM_LS_LH_X4%VDD_r29 x_PM_LS_LH_X4%VDD_37 x_PM_LS_LH_X4%VDD_13 7.68941
R_x_PM_LS_LH_X4%VDD_r30 x_PM_LS_LH_X4%VDD_9 VDD 10.4276
C_x_PM_LS_LH_X4%VSS_c0 x_PM_LS_LH_X4%VSS_50 VSS 0.0263388f
C_x_PM_LS_LH_X4%VSS_c1 x_PM_LS_LH_X4%VSS_47 VSS 0.00298886f
C_x_PM_LS_LH_X4%VSS_c2 x_PM_LS_LH_X4%VSS_46 VSS 0.00293947f
C_x_PM_LS_LH_X4%VSS_c3 x_PM_LS_LH_X4%VSS_45 VSS 0.00564863f
C_x_PM_LS_LH_X4%VSS_c4 x_PM_LS_LH_X4%VSS_43 VSS 0.2334f
C_x_PM_LS_LH_X4%VSS_c5 N_VSS_M5_b VSS 0.261569f
C_x_PM_LS_LH_X4%VSS_c6 N_VSS_M9_s VSS 0.0691504f
C_x_PM_LS_LH_X4%VSS_c7 x_PM_LS_LH_X4%VSS_27 VSS 0.026839f
C_x_PM_LS_LH_X4%VSS_c8 N_VSS_M7_d VSS 0.039059f
C_x_PM_LS_LH_X4%VSS_c9 x_PM_LS_LH_X4%VSS_19 VSS 0.0969483f
C_x_PM_LS_LH_X4%VSS_c10 x_PM_LS_LH_X4%VSS_18 VSS 0.056773f
C_x_PM_LS_LH_X4%VSS_c11 x_PM_LS_LH_X4%VSS_16 VSS 0.0106114f
C_x_PM_LS_LH_X4%VSS_c12 x_PM_LS_LH_X4%VSS_15 VSS 0.0565707f
C_x_PM_LS_LH_X4%VSS_c13 x_PM_LS_LH_X4%VSS_12 VSS 0.667932f
C_x_PM_LS_LH_X4%VSS_c14 x_PM_LS_LH_X4%VSS_11 VSS 0.0192462f
R_x_PM_LS_LH_X4%VSS_r15 N_VSS_M5_b x_PM_LS_LH_X4%VSS_50 0.13879
R_x_PM_LS_LH_X4%VSS_r16 N_VSS_M5_b x_PM_LS_LH_X4%VSS_43 0.138985
R_x_PM_LS_LH_X4%VSS_r17 x_PM_LS_LH_X4%VSS_34 x_PM_LS_LH_X4%VSS_47 0.0731438
R_x_PM_LS_LH_X4%VSS_r18 x_PM_LS_LH_X4%VSS_50 x_PM_LS_LH_X4%VSS_34 0.670588
R_x_PM_LS_LH_X4%VSS_r19 x_PM_LS_LH_X4%VSS_29 x_PM_LS_LH_X4%VSS_47 0.145286
R_x_PM_LS_LH_X4%VSS_r20 x_PM_LS_LH_X4%VSS_29 N_VSS_M9_s 1.425
R_x_PM_LS_LH_X4%VSS_r21 x_PM_LS_LH_X4%VSS_28 x_PM_LS_LH_X4%VSS_46 0.0731438
R_x_PM_LS_LH_X4%VSS_r22 x_PM_LS_LH_X4%VSS_27 x_PM_LS_LH_X4%VSS_47 0.0731438
R_x_PM_LS_LH_X4%VSS_r23 x_PM_LS_LH_X4%VSS_27 x_PM_LS_LH_X4%VSS_28 0.603529
R_x_PM_LS_LH_X4%VSS_r24 x_PM_LS_LH_X4%VSS_23 x_PM_LS_LH_X4%VSS_46 0.145286
R_x_PM_LS_LH_X4%VSS_r25 x_PM_LS_LH_X4%VSS_23 N_VSS_M7_d 0.665
R_x_PM_LS_LH_X4%VSS_r26 x_PM_LS_LH_X4%VSS_20 x_PM_LS_LH_X4%VSS_45 0.132285
R_x_PM_LS_LH_X4%VSS_r27 x_PM_LS_LH_X4%VSS_20 VSS 0.771176
R_x_PM_LS_LH_X4%VSS_r28 x_PM_LS_LH_X4%VSS_19 x_PM_LS_LH_X4%VSS_46 0.0731438
R_x_PM_LS_LH_X4%VSS_r29 x_PM_LS_LH_X4%VSS_19 VSS 0.849412
R_x_PM_LS_LH_X4%VSS_r30 x_PM_LS_LH_X4%VSS_18 x_PM_LS_LH_X4%VSS_45 0.0680382
R_x_PM_LS_LH_X4%VSS_r31 N_VSS_M5_d x_PM_LS_LH_X4%VSS_18 0.305065
R_x_PM_LS_LH_X4%VSS_r32 N_VSS_M5_b x_PM_LS_LH_X4%VSS_16 0.138595
R_x_PM_LS_LH_X4%VSS_r33 x_PM_LS_LH_X4%VSS_15 x_PM_LS_LH_X4%VSS_45 0.132285
R_x_PM_LS_LH_X4%VSS_r34 x_PM_LS_LH_X4%VSS_15 x_PM_LS_LH_X4%VSS_16 1.36353
R_x_PM_LS_LH_X4%VSS_r35 x_PM_LS_LH_X4%VSS_12 VSS 10.4276
R_x_PM_LS_LH_X4%VSS_r36 x_PM_LS_LH_X4%VSS_11 N_VSS_M5_b 0.140282
R_x_PM_LS_LH_X4%VSS_r37 x_PM_LS_LH_X4%VSS_43 x_PM_LS_LH_X4%VSS_11 7.68941
C_x_PM_LS_LH_X4%A_c0 x_PM_LS_LH_X4%A_11 VSS 0.0321869f
C_x_PM_LS_LH_X4%A_c1 x_PM_LS_LH_X4%A_10 VSS 0.00417485f
C_x_PM_LS_LH_X4%A_c2 x_PM_LS_LH_X4%A_9 VSS 0.0301779f
C_x_PM_LS_LH_X4%A_c3 N_A_M0_g VSS 0.0360347f
C_x_PM_LS_LH_X4%A_c4 N_A_M5_g VSS 0.0421999f
R_x_PM_LS_LH_X4%A_r5 x_PM_LS_LH_X4%A_11 x_PM_LS_LH_X4%A_13 25.0012
R_x_PM_LS_LH_X4%A_r6 x_PM_LS_LH_X4%A_11 A 0.00791667
R_x_PM_LS_LH_X4%A_r7 x_PM_LS_LH_X4%A_9 x_PM_LS_LH_X4%A_13 22.62
R_x_PM_LS_LH_X4%A_r8 x_PM_LS_LH_X4%A_9 x_PM_LS_LH_X4%A_10 0.043368
R_x_PM_LS_LH_X4%A_r9 x_PM_LS_LH_X4%A_5 x_PM_LS_LH_X4%A_10 4.56151
R_x_PM_LS_LH_X4%A_r10 x_PM_LS_LH_X4%A_5 N_A_M0_g 29.64
R_x_PM_LS_LH_X4%A_r11 x_PM_LS_LH_X4%A_1 x_PM_LS_LH_X4%A_10 4.56151
R_x_PM_LS_LH_X4%A_r12 x_PM_LS_LH_X4%A_1 N_A_M5_g 36.66
C_x_PM_LS_LH_X4%VDDL_c0 VDDL VSS 0.0711599f
C_x_PM_LS_LH_X4%VDDL_c1 x_PM_LS_LH_X4%VDDL_6 VSS 0.0389102f
R_x_PM_LS_LH_X4%VDDL_r2 N_VDDL_M0_b VDDL 0.10925
R_x_PM_LS_LH_X4%VDDL_r3 x_PM_LS_LH_X4%VDDL_6 N_VDDL_M0_b 0.095
R_x_PM_LS_LH_X4%VDDL_r4 N_VDDL_M0_d x_PM_LS_LH_X4%VDDL_6 0.473954
C_x_PM_LS_LH_X4%5_c0 x_PM_LS_LH_X4%5_31 VSS 0.00214831f
C_x_PM_LS_LH_X4%5_c1 x_PM_LS_LH_X4%5_28 VSS 0.0883987f
C_x_PM_LS_LH_X4%5_c2 N_5_M0_s VSS 0.0569733f
C_x_PM_LS_LH_X4%5_c3 N_5_M5_s VSS 0.0345899f
C_x_PM_LS_LH_X4%5_c4 x_PM_LS_LH_X4%5_15 VSS 0.0766786f
C_x_PM_LS_LH_X4%5_c5 x_PM_LS_LH_X4%5_14 VSS 0.00296759f
C_x_PM_LS_LH_X4%5_c6 N_5_M7_g VSS 0.0256413f
C_x_PM_LS_LH_X4%5_c7 N_5_M1_g VSS 0.0441239f
C_x_PM_LS_LH_X4%5_c8 N_5_M6_g VSS 0.0221474f
R_x_PM_LS_LH_X4%5_r9 x_PM_LS_LH_X4%5_28 x_PM_LS_LH_X4%5_32 25.0012
R_x_PM_LS_LH_X4%5_r10 x_PM_LS_LH_X4%5_26 x_PM_LS_LH_X4%5_31 0.0418175
R_x_PM_LS_LH_X4%5_r11 x_PM_LS_LH_X4%5_26 x_PM_LS_LH_X4%5_28 2.59214
R_x_PM_LS_LH_X4%5_r12 x_PM_LS_LH_X4%5_22 x_PM_LS_LH_X4%5_31 0.160909
R_x_PM_LS_LH_X4%5_r13 x_PM_LS_LH_X4%5_22 N_5_M0_s 1.64214
R_x_PM_LS_LH_X4%5_r14 x_PM_LS_LH_X4%5_18 x_PM_LS_LH_X4%5_31 0.160909
R_x_PM_LS_LH_X4%5_r15 x_PM_LS_LH_X4%5_18 N_5_M5_s 0.583571
R_x_PM_LS_LH_X4%5_r16 x_PM_LS_LH_X4%5_15 x_PM_LS_LH_X4%5_32 40.82
R_x_PM_LS_LH_X4%5_r17 x_PM_LS_LH_X4%5_13 x_PM_LS_LH_X4%5_32 18.98
R_x_PM_LS_LH_X4%5_r18 x_PM_LS_LH_X4%5_13 x_PM_LS_LH_X4%5_14 0.043368
R_x_PM_LS_LH_X4%5_r19 x_PM_LS_LH_X4%5_9 x_PM_LS_LH_X4%5_15 4.58872
R_x_PM_LS_LH_X4%5_r20 x_PM_LS_LH_X4%5_9 N_5_M7_g 17.16
R_x_PM_LS_LH_X4%5_r21 x_PM_LS_LH_X4%5_5 x_PM_LS_LH_X4%5_14 4.56151
R_x_PM_LS_LH_X4%5_r22 x_PM_LS_LH_X4%5_5 N_5_M1_g 49.14
R_x_PM_LS_LH_X4%5_r23 x_PM_LS_LH_X4%5_1 x_PM_LS_LH_X4%5_14 4.56151
R_x_PM_LS_LH_X4%5_r24 x_PM_LS_LH_X4%5_1 N_5_M6_g 17.16
C_x_PM_LS_LH_X4%6_c0 x_PM_LS_LH_X4%6_25 VSS 0.00305844f
C_x_PM_LS_LH_X4%6_c1 x_PM_LS_LH_X4%6_22 VSS 0.0514554f
C_x_PM_LS_LH_X4%6_c2 x_PM_LS_LH_X4%6_19 VSS 0.00558568f
C_x_PM_LS_LH_X4%6_c3 x_PM_LS_LH_X4%6_17 VSS 0.0480801f
C_x_PM_LS_LH_X4%6_c4 x_PM_LS_LH_X4%6_12 VSS 0.0454951f
C_x_PM_LS_LH_X4%6_c5 x_PM_LS_LH_X4%6_8 VSS 0.107736f
C_x_PM_LS_LH_X4%6_c6 x_PM_LS_LH_X4%6_5 VSS 0.0408775f
C_x_PM_LS_LH_X4%6_c7 N_6_M8_g VSS 0.0479133f
R_x_PM_LS_LH_X4%6_r8 x_PM_LS_LH_X4%6_22 x_PM_LS_LH_X4%6_26 25.0012
R_x_PM_LS_LH_X4%6_r9 x_PM_LS_LH_X4%6_20 x_PM_LS_LH_X4%6_25 0.0418175
R_x_PM_LS_LH_X4%6_r10 x_PM_LS_LH_X4%6_20 x_PM_LS_LH_X4%6_22 1.01786
R_x_PM_LS_LH_X4%6_r11 x_PM_LS_LH_X4%6_18 x_PM_LS_LH_X4%6_25 0.160909
R_x_PM_LS_LH_X4%6_r12 x_PM_LS_LH_X4%6_18 x_PM_LS_LH_X4%6_19 0.515714
R_x_PM_LS_LH_X4%6_r13 x_PM_LS_LH_X4%6_17 x_PM_LS_LH_X4%6_25 0.160909
R_x_PM_LS_LH_X4%6_r14 x_PM_LS_LH_X4%6_16 x_PM_LS_LH_X4%6_17 1.35714
R_x_PM_LS_LH_X4%6_r15 x_PM_LS_LH_X4%6_12 x_PM_LS_LH_X4%6_19 0.212317
R_x_PM_LS_LH_X4%6_r16 x_PM_LS_LH_X4%6_12 N_6_M1_d 1.34357
R_x_PM_LS_LH_X4%6_r17 x_PM_LS_LH_X4%6_8 x_PM_LS_LH_X4%6_16 0.212317
R_x_PM_LS_LH_X4%6_r18 x_PM_LS_LH_X4%6_8 N_6_M6_d 1.34357
R_x_PM_LS_LH_X4%6_r19 x_PM_LS_LH_X4%6_5 x_PM_LS_LH_X4%6_26 20.02
R_x_PM_LS_LH_X4%6_r20 x_PM_LS_LH_X4%6_1 x_PM_LS_LH_X4%6_5 4.58872
R_x_PM_LS_LH_X4%6_r21 x_PM_LS_LH_X4%6_1 N_6_M8_g 44.46
C_x_PM_LS_LH_X4%7_c0 x_PM_LS_LH_X4%7_25 VSS 0.0154248f
C_x_PM_LS_LH_X4%7_c1 x_PM_LS_LH_X4%7_20 VSS 0.105774f
C_x_PM_LS_LH_X4%7_c2 x_PM_LS_LH_X4%7_18 VSS 0.0156007f
C_x_PM_LS_LH_X4%7_c3 x_PM_LS_LH_X4%7_17 VSS 0.021281f
C_x_PM_LS_LH_X4%7_c4 x_PM_LS_LH_X4%7_16 VSS 0.0255108f
C_x_PM_LS_LH_X4%7_c5 x_PM_LS_LH_X4%7_15 VSS 0.0494068f
C_x_PM_LS_LH_X4%7_c6 N_7_M2_s VSS 0.061196f
C_x_PM_LS_LH_X4%7_c7 N_7_M7_s VSS 0.0494091f
C_x_PM_LS_LH_X4%7_c8 N_7_M3_g VSS 0.0609809f
R_x_PM_LS_LH_X4%7_r9 x_PM_LS_LH_X4%7_22 x_PM_LS_LH_X4%7_25 4.42
R_x_PM_LS_LH_X4%7_r10 x_PM_LS_LH_X4%7_21 x_PM_LS_LH_X4%7_22 25.0012
R_x_PM_LS_LH_X4%7_r11 x_PM_LS_LH_X4%7_20 x_PM_LS_LH_X4%7_21 0.0141545
R_x_PM_LS_LH_X4%7_r12 x_PM_LS_LH_X4%7_19 x_PM_LS_LH_X4%7_20 1.52
R_x_PM_LS_LH_X4%7_r13 x_PM_LS_LH_X4%7_17 x_PM_LS_LH_X4%7_21 0.198162
R_x_PM_LS_LH_X4%7_r14 x_PM_LS_LH_X4%7_17 x_PM_LS_LH_X4%7_18 0.922857
R_x_PM_LS_LH_X4%7_r15 x_PM_LS_LH_X4%7_15 x_PM_LS_LH_X4%7_19 0.212317
R_x_PM_LS_LH_X4%7_r16 x_PM_LS_LH_X4%7_15 x_PM_LS_LH_X4%7_16 0.922857
R_x_PM_LS_LH_X4%7_r17 x_PM_LS_LH_X4%7_11 x_PM_LS_LH_X4%7_18 0.212317
R_x_PM_LS_LH_X4%7_r18 x_PM_LS_LH_X4%7_11 N_7_M2_s 1.94071
R_x_PM_LS_LH_X4%7_r19 x_PM_LS_LH_X4%7_7 x_PM_LS_LH_X4%7_16 0.212317
R_x_PM_LS_LH_X4%7_r20 x_PM_LS_LH_X4%7_7 N_7_M7_s 0.665
R_x_PM_LS_LH_X4%7_r21 x_PM_LS_LH_X4%7_1 x_PM_LS_LH_X4%7_25 1.95
R_x_PM_LS_LH_X4%7_r22 x_PM_LS_LH_X4%7_1 N_7_M3_g 60.45
C_x_PM_LS_LH_X4%8_c0 x_PM_LS_LH_X4%8_39 VSS 0.0107463f
C_x_PM_LS_LH_X4%8_c1 x_PM_LS_LH_X4%8_32 VSS 0.00906029f
C_x_PM_LS_LH_X4%8_c2 x_PM_LS_LH_X4%8_31 VSS 0.0285607f
C_x_PM_LS_LH_X4%8_c3 x_PM_LS_LH_X4%8_30 VSS 0.0445709f
C_x_PM_LS_LH_X4%8_c4 N_8_M3_d VSS 0.0438401f
C_x_PM_LS_LH_X4%8_c5 x_PM_LS_LH_X4%8_23 VSS 0.0303326f
C_x_PM_LS_LH_X4%8_c6 N_8_M8_d VSS 0.0956285f
C_x_PM_LS_LH_X4%8_c7 x_PM_LS_LH_X4%8_17 VSS 0.0776321f
C_x_PM_LS_LH_X4%8_c8 x_PM_LS_LH_X4%8_16 VSS 0.0152635f
C_x_PM_LS_LH_X4%8_c9 N_8_M4_g VSS 0.073546f
C_x_PM_LS_LH_X4%8_c10 N_8_M9_g VSS 0.0572503f
C_x_PM_LS_LH_X4%8_c11 N_8_M2_g VSS 0.0326311f
R_x_PM_LS_LH_X4%8_r12 x_PM_LS_LH_X4%8_37 x_PM_LS_LH_X4%8_39 3.9
R_x_PM_LS_LH_X4%8_r13 x_PM_LS_LH_X4%8_30 x_PM_LS_LH_X4%8_31 0.0272847
R_x_PM_LS_LH_X4%8_r14 x_PM_LS_LH_X4%8_28 x_PM_LS_LH_X4%8_30 0.417657
R_x_PM_LS_LH_X4%8_r15 x_PM_LS_LH_X4%8_28 x_PM_LS_LH_X4%8_37 25.0012
R_x_PM_LS_LH_X4%8_r16 x_PM_LS_LH_X4%8_24 x_PM_LS_LH_X4%8_32 0.273842
R_x_PM_LS_LH_X4%8_r17 x_PM_LS_LH_X4%8_24 N_8_M3_d 0.610714
R_x_PM_LS_LH_X4%8_r18 x_PM_LS_LH_X4%8_23 x_PM_LS_LH_X4%8_32 0.273842
R_x_PM_LS_LH_X4%8_r19 x_PM_LS_LH_X4%8_22 x_PM_LS_LH_X4%8_31 0.266978
R_x_PM_LS_LH_X4%8_r20 x_PM_LS_LH_X4%8_22 x_PM_LS_LH_X4%8_23 1.16714
R_x_PM_LS_LH_X4%8_r21 x_PM_LS_LH_X4%8_18 x_PM_LS_LH_X4%8_31 0.266978
R_x_PM_LS_LH_X4%8_r22 x_PM_LS_LH_X4%8_18 N_8_M8_d 1.58786
R_x_PM_LS_LH_X4%8_r23 x_PM_LS_LH_X4%8_17 x_PM_LS_LH_X4%8_32 0.0307623
R_x_PM_LS_LH_X4%8_r24 x_PM_LS_LH_X4%8_33 x_PM_LS_LH_X4%8_16 3.9
R_x_PM_LS_LH_X4%8_r25 x_PM_LS_LH_X4%8_15 x_PM_LS_LH_X4%8_17 0.514126
R_x_PM_LS_LH_X4%8_r26 x_PM_LS_LH_X4%8_15 x_PM_LS_LH_X4%8_16 25.0012
R_x_PM_LS_LH_X4%8_r27 x_PM_LS_LH_X4%8_9 x_PM_LS_LH_X4%8_39 1.95
R_x_PM_LS_LH_X4%8_r28 x_PM_LS_LH_X4%8_9 N_8_M4_g 56.16
R_x_PM_LS_LH_X4%8_r29 x_PM_LS_LH_X4%8_5 x_PM_LS_LH_X4%8_39 1.95
R_x_PM_LS_LH_X4%8_r30 x_PM_LS_LH_X4%8_5 N_8_M9_g 37.44
R_x_PM_LS_LH_X4%8_r31 x_PM_LS_LH_X4%8_1 x_PM_LS_LH_X4%8_33 1.95
R_x_PM_LS_LH_X4%8_r32 x_PM_LS_LH_X4%8_1 N_8_M2_g 23.79
C_x_PM_LS_LH_X4%Z_c0 N_Z_M9_d VSS 0.0903812f
R_x_PM_LS_LH_X4%Z_r1 Z N_Z_M4_d 1.50643
R_x_PM_LS_LH_X4%Z_r2 N_Z_M9_d Z 1.15357
.ENDS

********************************************************************************
*
* END
*
********************************************************************************
