*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2010, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *         buildcell, v2010.08-HR32-SP3-2010-08-05 - build 1009061800         *
* *                                                                            *
* ******************************************************************************
*
*
* Running on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr).
* Local time is now Fri, 3 Dec 2010, 19:32:04.
* Main process id is 28006.
*
********************************************************************************
*                                                                              *
* Cellname:   BUF_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
* Written on brazil06.nangate.com.br for user Giancarlo Franciscatto (gfr)     *
* at 19:32:04 on Fri, 3 Dec 2010.                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X32 VDD VSS A Z
*.PININFO VDD:P VSS:G A:I Z:O
*.EQN Z=A
M_M48 N_4_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.630000U L=0.050000U
M_M49 N_VDD_M1_d N_A_M1_g N_4_M0_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M50 N_4_M2_d N_A_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M51 N_VDD_M3_d N_A_M3_g N_4_M2_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M52 N_4_M4_d N_A_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M53 N_VDD_M5_d N_A_M5_g N_4_M4_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M54 N_4_M6_d N_A_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M55 N_VDD_M7_d N_A_M7_g N_4_M6_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M56 N_4_M8_d N_A_M8_g N_VDD_M7_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M57 N_VDD_M9_d N_A_M9_g N_4_M8_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M58 N_4_M10_d N_A_M10_g N_VDD_M9_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M59 N_VDD_M11_d N_A_M11_g N_4_M10_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M60 N_4_M12_d N_A_M12_g N_VDD_M11_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M61 N_VDD_M13_d N_A_M13_g N_4_M12_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M62 N_4_M14_d N_A_M14_g N_VDD_M13_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M63 N_VDD_M15_d N_A_M15_g N_4_M14_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M64 N_Z_M16_d N_4_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M65 N_VDD_M17_d N_4_M17_g N_Z_M16_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M66 N_Z_M18_d N_4_M18_g N_VDD_M17_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M67 N_VDD_M19_d N_4_M19_g N_Z_M18_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M68 N_Z_M20_d N_4_M20_g N_VDD_M19_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M69 N_VDD_M21_d N_4_M21_g N_Z_M20_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M70 N_Z_M22_d N_4_M22_g N_VDD_M21_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M71 N_VDD_M23_d N_4_M23_g N_Z_M22_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M72 N_Z_M24_d N_4_M24_g N_VDD_M23_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M73 N_VDD_M25_d N_4_M25_g N_Z_M24_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M74 N_Z_M26_d N_4_M26_g N_VDD_M25_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M75 N_VDD_M27_d N_4_M27_g N_Z_M26_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M76 N_Z_M28_d N_4_M28_g N_VDD_M27_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M77 N_VDD_M29_d N_4_M29_g N_Z_M28_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M78 N_Z_M30_d N_4_M30_g N_VDD_M29_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M79 N_VDD_M31_d N_4_M31_g N_Z_M30_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M80 N_Z_M32_d N_4_M32_g N_VDD_M31_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M81 N_VDD_M33_d N_4_M33_g N_Z_M32_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M82 N_Z_M34_d N_4_M34_g N_VDD_M33_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M83 N_VDD_M35_d N_4_M35_g N_Z_M34_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M84 N_Z_M36_d N_4_M36_g N_VDD_M35_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M85 N_VDD_M37_d N_4_M37_g N_Z_M36_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M86 N_Z_M38_d N_4_M38_g N_VDD_M37_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M87 N_VDD_M39_d N_4_M39_g N_Z_M38_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M88 N_Z_M40_d N_4_M40_g N_VDD_M39_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M89 N_VDD_M41_d N_4_M41_g N_Z_M40_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M90 N_Z_M42_d N_4_M42_g N_VDD_M41_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M91 N_VDD_M43_d N_4_M43_g N_Z_M42_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M92 N_Z_M44_d N_4_M44_g N_VDD_M43_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M93 N_VDD_M45_d N_4_M45_g N_Z_M44_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M94 N_Z_M46_d N_4_M46_g N_VDD_M45_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M95 N_VDD_M47_d N_4_M47_g N_Z_M46_d VDD PMOS_VTL W=0.630000U L=0.050000U
M_M0 N_4_M48_d N_A_M48_g N_VSS_M48_s VSS NMOS_VTL W=0.415000U L=0.050000U
M_M1 N_VSS_M49_d N_A_M49_g N_4_M48_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M2 N_4_M50_d N_A_M50_g N_VSS_M49_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M3 N_VSS_M51_d N_A_M51_g N_4_M50_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M4 N_4_M52_d N_A_M52_g N_VSS_M51_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M5 N_VSS_M53_d N_A_M53_g N_4_M52_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M6 N_4_M54_d N_A_M54_g N_VSS_M53_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M7 N_VSS_M55_d N_A_M55_g N_4_M54_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M8 N_4_M56_d N_A_M56_g N_VSS_M55_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M9 N_VSS_M57_d N_A_M57_g N_4_M56_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M10 N_4_M58_d N_A_M58_g N_VSS_M57_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M11 N_VSS_M59_d N_A_M59_g N_4_M58_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M12 N_4_M60_d N_A_M60_g N_VSS_M59_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M13 N_VSS_M61_d N_A_M61_g N_4_M60_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M14 N_4_M62_d N_A_M62_g N_VSS_M61_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M15 N_VSS_M63_d N_A_M63_g N_4_M62_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M16 N_Z_M64_d N_4_M64_g N_VSS_M63_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M17 N_VSS_M65_d N_4_M65_g N_Z_M64_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M18 N_Z_M66_d N_4_M66_g N_VSS_M65_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M19 N_VSS_M67_d N_4_M67_g N_Z_M66_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M20 N_Z_M68_d N_4_M68_g N_VSS_M67_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M21 N_VSS_M69_d N_4_M69_g N_Z_M68_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M22 N_Z_M70_d N_4_M70_g N_VSS_M69_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M23 N_VSS_M71_d N_4_M71_g N_Z_M70_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M24 N_Z_M72_d N_4_M72_g N_VSS_M71_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M25 N_VSS_M73_d N_4_M73_g N_Z_M72_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M26 N_Z_M74_d N_4_M74_g N_VSS_M73_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M27 N_VSS_M75_d N_4_M75_g N_Z_M74_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M28 N_Z_M76_d N_4_M76_g N_VSS_M75_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M29 N_VSS_M77_d N_4_M77_g N_Z_M76_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M30 N_Z_M78_d N_4_M78_g N_VSS_M77_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M31 N_VSS_M79_d N_4_M79_g N_Z_M78_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M32 N_Z_M80_d N_4_M80_g N_VSS_M79_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M33 N_VSS_M81_d N_4_M81_g N_Z_M80_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M34 N_Z_M82_d N_4_M82_g N_VSS_M81_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M35 N_VSS_M83_d N_4_M83_g N_Z_M82_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M36 N_Z_M84_d N_4_M84_g N_VSS_M83_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M37 N_VSS_M85_d N_4_M85_g N_Z_M84_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M38 N_Z_M86_d N_4_M86_g N_VSS_M85_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M39 N_VSS_M87_d N_4_M87_g N_Z_M86_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M40 N_Z_M88_d N_4_M88_g N_VSS_M87_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M41 N_VSS_M89_d N_4_M89_g N_Z_M88_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M42 N_Z_M90_d N_4_M90_g N_VSS_M89_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M43 N_VSS_M91_d N_4_M91_g N_Z_M90_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M44 N_Z_M92_d N_4_M92_g N_VSS_M91_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M45 N_VSS_M93_d N_4_M93_g N_Z_M92_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M46 N_Z_M94_d N_4_M94_g N_VSS_M93_d VSS NMOS_VTL W=0.415000U L=0.050000U
M_M47 N_VSS_M95_d N_4_M95_g N_Z_M94_d VSS NMOS_VTL W=0.415000U L=0.050000U
C_x_PM_BUF_X32%VDD_c0 x_PM_BUF_X32%VDD_217 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c1 x_PM_BUF_X32%VDD_216 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c2 x_PM_BUF_X32%VDD_215 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c3 x_PM_BUF_X32%VDD_214 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c4 x_PM_BUF_X32%VDD_213 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c5 x_PM_BUF_X32%VDD_212 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c6 x_PM_BUF_X32%VDD_211 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c7 x_PM_BUF_X32%VDD_210 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c8 x_PM_BUF_X32%VDD_209 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c9 x_PM_BUF_X32%VDD_208 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c10 x_PM_BUF_X32%VDD_207 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c11 x_PM_BUF_X32%VDD_206 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c12 x_PM_BUF_X32%VDD_205 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c13 x_PM_BUF_X32%VDD_204 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c14 x_PM_BUF_X32%VDD_203 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c15 x_PM_BUF_X32%VDD_202 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c16 x_PM_BUF_X32%VDD_201 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c17 x_PM_BUF_X32%VDD_200 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c18 x_PM_BUF_X32%VDD_199 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c19 x_PM_BUF_X32%VDD_198 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c20 x_PM_BUF_X32%VDD_197 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c21 x_PM_BUF_X32%VDD_196 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c22 x_PM_BUF_X32%VDD_195 VSS 2.71933e-18
C_x_PM_BUF_X32%VDD_c23 x_PM_BUF_X32%VDD_185 VSS 2.71304e-16
C_x_PM_BUF_X32%VDD_c24 N_VDD_M47_d VSS 2.61478e-17
C_x_PM_BUF_X32%VDD_c25 x_PM_BUF_X32%VDD_179 VSS 3.51947e-17
C_x_PM_BUF_X32%VDD_c26 N_VDD_M45_d VSS 3.01214e-17
C_x_PM_BUF_X32%VDD_c27 x_PM_BUF_X32%VDD_173 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c28 N_VDD_M43_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c29 x_PM_BUF_X32%VDD_167 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c30 N_VDD_M41_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c31 x_PM_BUF_X32%VDD_161 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c32 N_VDD_M39_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c33 x_PM_BUF_X32%VDD_155 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c34 N_VDD_M37_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c35 x_PM_BUF_X32%VDD_149 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c36 N_VDD_M35_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c37 x_PM_BUF_X32%VDD_143 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c38 N_VDD_M33_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c39 x_PM_BUF_X32%VDD_137 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c40 N_VDD_M31_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c41 x_PM_BUF_X32%VDD_131 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c42 N_VDD_M29_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c43 x_PM_BUF_X32%VDD_125 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c44 N_VDD_M27_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c45 x_PM_BUF_X32%VDD_119 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c46 N_VDD_M25_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c47 x_PM_BUF_X32%VDD_113 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c48 N_VDD_M23_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c49 x_PM_BUF_X32%VDD_107 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c50 N_VDD_M21_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c51 x_PM_BUF_X32%VDD_101 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c52 N_VDD_M19_d VSS 1.91022e-17
C_x_PM_BUF_X32%VDD_c53 x_PM_BUF_X32%VDD_95 VSS 2.36831e-17
C_x_PM_BUF_X32%VDD_c54 N_VDD_M17_d VSS 1.93285e-17
C_x_PM_BUF_X32%VDD_c55 x_PM_BUF_X32%VDD_89 VSS 2.52297e-17
C_x_PM_BUF_X32%VDD_c56 N_VDD_M15_d VSS 1.52059e-17
C_x_PM_BUF_X32%VDD_c57 x_PM_BUF_X32%VDD_83 VSS 2.33426e-17
C_x_PM_BUF_X32%VDD_c58 N_VDD_M13_d VSS 2.99638e-17
C_x_PM_BUF_X32%VDD_c59 x_PM_BUF_X32%VDD_77 VSS 2.44262e-17
C_x_PM_BUF_X32%VDD_c60 N_VDD_M11_d VSS 2.99081e-17
C_x_PM_BUF_X32%VDD_c61 x_PM_BUF_X32%VDD_71 VSS 2.44262e-17
C_x_PM_BUF_X32%VDD_c62 N_VDD_M9_d VSS 2.99081e-17
C_x_PM_BUF_X32%VDD_c63 x_PM_BUF_X32%VDD_65 VSS 2.44262e-17
C_x_PM_BUF_X32%VDD_c64 N_VDD_M7_d VSS 2.99081e-17
C_x_PM_BUF_X32%VDD_c65 x_PM_BUF_X32%VDD_59 VSS 2.44262e-17
C_x_PM_BUF_X32%VDD_c66 N_VDD_M5_d VSS 2.99081e-17
C_x_PM_BUF_X32%VDD_c67 x_PM_BUF_X32%VDD_53 VSS 2.44262e-17
C_x_PM_BUF_X32%VDD_c68 N_VDD_M3_d VSS 2.99081e-17
C_x_PM_BUF_X32%VDD_c69 x_PM_BUF_X32%VDD_47 VSS 2.44262e-17
C_x_PM_BUF_X32%VDD_c70 N_VDD_M1_d VSS 2.98506e-17
C_x_PM_BUF_X32%VDD_c71 x_PM_BUF_X32%VDD_42 VSS 1.89637e-17
C_x_PM_BUF_X32%VDD_c72 x_PM_BUF_X32%VDD_41 VSS 2.43887e-17
C_x_PM_BUF_X32%VDD_c73 N_VDD_M0_s VSS 1.72583e-17
C_x_PM_BUF_X32%VDD_c74 x_PM_BUF_X32%VDD_36 VSS 1.92462e-17
C_x_PM_BUF_X32%VDD_c75 x_PM_BUF_X32%VDD_35 VSS 2.334e-16
C_x_PM_BUF_X32%VDD_c76 x_PM_BUF_X32%VDD_32 VSS 1.15638e-15
R_x_PM_BUF_X32%VDD_r77 x_PM_BUF_X32%VDD_218 VDD 0.436117
R_x_PM_BUF_X32%VDD_r78 VDD x_PM_BUF_X32%VDD_194 0.392137
R_x_PM_BUF_X32%VDD_r79 x_PM_BUF_X32%VDD_185 VDD 0.143697
R_x_PM_BUF_X32%VDD_r80 x_PM_BUF_X32%VDD_185 VDD 3.84471
R_x_PM_BUF_X32%VDD_r81 x_PM_BUF_X32%VDD_218 N_VDD_M47_d 0.230714
R_x_PM_BUF_X32%VDD_r82 x_PM_BUF_X32%VDD_180 x_PM_BUF_X32%VDD_217 0.0731438
R_x_PM_BUF_X32%VDD_r83 x_PM_BUF_X32%VDD_179 x_PM_BUF_X32%VDD_218 0.0753891
R_x_PM_BUF_X32%VDD_r84 x_PM_BUF_X32%VDD_179 x_PM_BUF_X32%VDD_180 0.692941
R_x_PM_BUF_X32%VDD_r85 x_PM_BUF_X32%VDD_175 x_PM_BUF_X32%VDD_217 0.145286
R_x_PM_BUF_X32%VDD_r86 x_PM_BUF_X32%VDD_175 N_VDD_M45_d 0.230714
R_x_PM_BUF_X32%VDD_r87 x_PM_BUF_X32%VDD_174 x_PM_BUF_X32%VDD_216 0.0731438
R_x_PM_BUF_X32%VDD_r88 x_PM_BUF_X32%VDD_173 x_PM_BUF_X32%VDD_217 0.0731438
R_x_PM_BUF_X32%VDD_r89 x_PM_BUF_X32%VDD_173 x_PM_BUF_X32%VDD_174 0.692941
R_x_PM_BUF_X32%VDD_r90 x_PM_BUF_X32%VDD_169 x_PM_BUF_X32%VDD_216 0.145286
R_x_PM_BUF_X32%VDD_r91 x_PM_BUF_X32%VDD_169 N_VDD_M43_d 0.230714
R_x_PM_BUF_X32%VDD_r92 x_PM_BUF_X32%VDD_168 x_PM_BUF_X32%VDD_215 0.0731438
R_x_PM_BUF_X32%VDD_r93 x_PM_BUF_X32%VDD_167 x_PM_BUF_X32%VDD_216 0.0731438
R_x_PM_BUF_X32%VDD_r94 x_PM_BUF_X32%VDD_167 x_PM_BUF_X32%VDD_168 0.692941
R_x_PM_BUF_X32%VDD_r95 x_PM_BUF_X32%VDD_163 x_PM_BUF_X32%VDD_215 0.145286
R_x_PM_BUF_X32%VDD_r96 x_PM_BUF_X32%VDD_163 N_VDD_M41_d 0.230714
R_x_PM_BUF_X32%VDD_r97 x_PM_BUF_X32%VDD_162 x_PM_BUF_X32%VDD_214 0.0731438
R_x_PM_BUF_X32%VDD_r98 x_PM_BUF_X32%VDD_161 x_PM_BUF_X32%VDD_215 0.0731438
R_x_PM_BUF_X32%VDD_r99 x_PM_BUF_X32%VDD_161 x_PM_BUF_X32%VDD_162 0.692941
R_x_PM_BUF_X32%VDD_r100 x_PM_BUF_X32%VDD_157 x_PM_BUF_X32%VDD_214 0.145286
R_x_PM_BUF_X32%VDD_r101 x_PM_BUF_X32%VDD_157 N_VDD_M39_d 0.230714
R_x_PM_BUF_X32%VDD_r102 x_PM_BUF_X32%VDD_156 x_PM_BUF_X32%VDD_213 0.0731438
R_x_PM_BUF_X32%VDD_r103 x_PM_BUF_X32%VDD_155 x_PM_BUF_X32%VDD_214 0.0731438
R_x_PM_BUF_X32%VDD_r104 x_PM_BUF_X32%VDD_155 x_PM_BUF_X32%VDD_156 0.692941
R_x_PM_BUF_X32%VDD_r105 x_PM_BUF_X32%VDD_151 x_PM_BUF_X32%VDD_213 0.145286
R_x_PM_BUF_X32%VDD_r106 x_PM_BUF_X32%VDD_151 N_VDD_M37_d 0.230714
R_x_PM_BUF_X32%VDD_r107 x_PM_BUF_X32%VDD_150 x_PM_BUF_X32%VDD_212 0.0731438
R_x_PM_BUF_X32%VDD_r108 x_PM_BUF_X32%VDD_149 x_PM_BUF_X32%VDD_213 0.0731438
R_x_PM_BUF_X32%VDD_r109 x_PM_BUF_X32%VDD_149 x_PM_BUF_X32%VDD_150 0.692941
R_x_PM_BUF_X32%VDD_r110 x_PM_BUF_X32%VDD_145 x_PM_BUF_X32%VDD_212 0.145286
R_x_PM_BUF_X32%VDD_r111 x_PM_BUF_X32%VDD_145 N_VDD_M35_d 0.230714
R_x_PM_BUF_X32%VDD_r112 x_PM_BUF_X32%VDD_144 x_PM_BUF_X32%VDD_211 0.0731438
R_x_PM_BUF_X32%VDD_r113 x_PM_BUF_X32%VDD_143 x_PM_BUF_X32%VDD_212 0.0731438
R_x_PM_BUF_X32%VDD_r114 x_PM_BUF_X32%VDD_143 x_PM_BUF_X32%VDD_144 0.692941
R_x_PM_BUF_X32%VDD_r115 x_PM_BUF_X32%VDD_139 x_PM_BUF_X32%VDD_211 0.145286
R_x_PM_BUF_X32%VDD_r116 x_PM_BUF_X32%VDD_139 N_VDD_M33_d 0.230714
R_x_PM_BUF_X32%VDD_r117 x_PM_BUF_X32%VDD_138 x_PM_BUF_X32%VDD_210 0.0731438
R_x_PM_BUF_X32%VDD_r118 x_PM_BUF_X32%VDD_137 x_PM_BUF_X32%VDD_211 0.0731438
R_x_PM_BUF_X32%VDD_r119 x_PM_BUF_X32%VDD_137 x_PM_BUF_X32%VDD_138 0.692941
R_x_PM_BUF_X32%VDD_r120 x_PM_BUF_X32%VDD_133 x_PM_BUF_X32%VDD_210 0.145286
R_x_PM_BUF_X32%VDD_r121 x_PM_BUF_X32%VDD_133 N_VDD_M31_d 0.230714
R_x_PM_BUF_X32%VDD_r122 x_PM_BUF_X32%VDD_132 x_PM_BUF_X32%VDD_209 0.0731438
R_x_PM_BUF_X32%VDD_r123 x_PM_BUF_X32%VDD_131 x_PM_BUF_X32%VDD_210 0.0731438
R_x_PM_BUF_X32%VDD_r124 x_PM_BUF_X32%VDD_131 x_PM_BUF_X32%VDD_132 0.692941
R_x_PM_BUF_X32%VDD_r125 x_PM_BUF_X32%VDD_127 x_PM_BUF_X32%VDD_209 0.145286
R_x_PM_BUF_X32%VDD_r126 x_PM_BUF_X32%VDD_127 N_VDD_M29_d 0.230714
R_x_PM_BUF_X32%VDD_r127 x_PM_BUF_X32%VDD_126 x_PM_BUF_X32%VDD_208 0.0731438
R_x_PM_BUF_X32%VDD_r128 x_PM_BUF_X32%VDD_125 x_PM_BUF_X32%VDD_209 0.0731438
R_x_PM_BUF_X32%VDD_r129 x_PM_BUF_X32%VDD_125 x_PM_BUF_X32%VDD_126 0.692941
R_x_PM_BUF_X32%VDD_r130 x_PM_BUF_X32%VDD_121 x_PM_BUF_X32%VDD_208 0.145286
R_x_PM_BUF_X32%VDD_r131 x_PM_BUF_X32%VDD_121 N_VDD_M27_d 0.230714
R_x_PM_BUF_X32%VDD_r132 x_PM_BUF_X32%VDD_120 x_PM_BUF_X32%VDD_207 0.0731438
R_x_PM_BUF_X32%VDD_r133 x_PM_BUF_X32%VDD_119 x_PM_BUF_X32%VDD_208 0.0731438
R_x_PM_BUF_X32%VDD_r134 x_PM_BUF_X32%VDD_119 x_PM_BUF_X32%VDD_120 0.692941
R_x_PM_BUF_X32%VDD_r135 x_PM_BUF_X32%VDD_115 x_PM_BUF_X32%VDD_207 0.145286
R_x_PM_BUF_X32%VDD_r136 x_PM_BUF_X32%VDD_115 N_VDD_M25_d 0.230714
R_x_PM_BUF_X32%VDD_r137 x_PM_BUF_X32%VDD_114 x_PM_BUF_X32%VDD_206 0.0731438
R_x_PM_BUF_X32%VDD_r138 x_PM_BUF_X32%VDD_113 x_PM_BUF_X32%VDD_207 0.0731438
R_x_PM_BUF_X32%VDD_r139 x_PM_BUF_X32%VDD_113 x_PM_BUF_X32%VDD_114 0.692941
R_x_PM_BUF_X32%VDD_r140 x_PM_BUF_X32%VDD_109 x_PM_BUF_X32%VDD_206 0.145286
R_x_PM_BUF_X32%VDD_r141 x_PM_BUF_X32%VDD_109 N_VDD_M23_d 0.230714
R_x_PM_BUF_X32%VDD_r142 x_PM_BUF_X32%VDD_108 x_PM_BUF_X32%VDD_205 0.0731438
R_x_PM_BUF_X32%VDD_r143 x_PM_BUF_X32%VDD_107 x_PM_BUF_X32%VDD_206 0.0731438
R_x_PM_BUF_X32%VDD_r144 x_PM_BUF_X32%VDD_107 x_PM_BUF_X32%VDD_108 0.692941
R_x_PM_BUF_X32%VDD_r145 x_PM_BUF_X32%VDD_103 x_PM_BUF_X32%VDD_205 0.145286
R_x_PM_BUF_X32%VDD_r146 x_PM_BUF_X32%VDD_103 N_VDD_M21_d 0.230714
R_x_PM_BUF_X32%VDD_r147 x_PM_BUF_X32%VDD_102 x_PM_BUF_X32%VDD_204 0.0731438
R_x_PM_BUF_X32%VDD_r148 x_PM_BUF_X32%VDD_101 x_PM_BUF_X32%VDD_205 0.0731438
R_x_PM_BUF_X32%VDD_r149 x_PM_BUF_X32%VDD_101 x_PM_BUF_X32%VDD_102 0.692941
R_x_PM_BUF_X32%VDD_r150 x_PM_BUF_X32%VDD_97 x_PM_BUF_X32%VDD_204 0.145286
R_x_PM_BUF_X32%VDD_r151 x_PM_BUF_X32%VDD_97 N_VDD_M19_d 0.230714
R_x_PM_BUF_X32%VDD_r152 x_PM_BUF_X32%VDD_96 x_PM_BUF_X32%VDD_203 0.0731438
R_x_PM_BUF_X32%VDD_r153 x_PM_BUF_X32%VDD_95 x_PM_BUF_X32%VDD_204 0.0731438
R_x_PM_BUF_X32%VDD_r154 x_PM_BUF_X32%VDD_95 x_PM_BUF_X32%VDD_96 0.692941
R_x_PM_BUF_X32%VDD_r155 x_PM_BUF_X32%VDD_91 x_PM_BUF_X32%VDD_203 0.145286
R_x_PM_BUF_X32%VDD_r156 x_PM_BUF_X32%VDD_91 N_VDD_M17_d 0.230714
R_x_PM_BUF_X32%VDD_r157 x_PM_BUF_X32%VDD_90 x_PM_BUF_X32%VDD_202 0.0731438
R_x_PM_BUF_X32%VDD_r158 x_PM_BUF_X32%VDD_89 x_PM_BUF_X32%VDD_203 0.0731438
R_x_PM_BUF_X32%VDD_r159 x_PM_BUF_X32%VDD_89 x_PM_BUF_X32%VDD_90 0.737647
R_x_PM_BUF_X32%VDD_r160 x_PM_BUF_X32%VDD_85 x_PM_BUF_X32%VDD_202 0.145286
R_x_PM_BUF_X32%VDD_r161 x_PM_BUF_X32%VDD_85 N_VDD_M15_d 0.230714
R_x_PM_BUF_X32%VDD_r162 x_PM_BUF_X32%VDD_84 x_PM_BUF_X32%VDD_201 0.0731438
R_x_PM_BUF_X32%VDD_r163 x_PM_BUF_X32%VDD_83 x_PM_BUF_X32%VDD_202 0.0731438
R_x_PM_BUF_X32%VDD_r164 x_PM_BUF_X32%VDD_83 x_PM_BUF_X32%VDD_84 0.704118
R_x_PM_BUF_X32%VDD_r165 x_PM_BUF_X32%VDD_79 x_PM_BUF_X32%VDD_201 0.145286
R_x_PM_BUF_X32%VDD_r166 x_PM_BUF_X32%VDD_79 N_VDD_M13_d 0.230714
R_x_PM_BUF_X32%VDD_r167 x_PM_BUF_X32%VDD_78 x_PM_BUF_X32%VDD_200 0.0731438
R_x_PM_BUF_X32%VDD_r168 x_PM_BUF_X32%VDD_77 x_PM_BUF_X32%VDD_201 0.0731438
R_x_PM_BUF_X32%VDD_r169 x_PM_BUF_X32%VDD_77 x_PM_BUF_X32%VDD_78 0.692941
R_x_PM_BUF_X32%VDD_r170 x_PM_BUF_X32%VDD_73 x_PM_BUF_X32%VDD_200 0.145286
R_x_PM_BUF_X32%VDD_r171 x_PM_BUF_X32%VDD_73 N_VDD_M11_d 0.230714
R_x_PM_BUF_X32%VDD_r172 x_PM_BUF_X32%VDD_72 x_PM_BUF_X32%VDD_199 0.0731438
R_x_PM_BUF_X32%VDD_r173 x_PM_BUF_X32%VDD_71 x_PM_BUF_X32%VDD_200 0.0731438
R_x_PM_BUF_X32%VDD_r174 x_PM_BUF_X32%VDD_71 x_PM_BUF_X32%VDD_72 0.692941
R_x_PM_BUF_X32%VDD_r175 x_PM_BUF_X32%VDD_67 x_PM_BUF_X32%VDD_199 0.145286
R_x_PM_BUF_X32%VDD_r176 x_PM_BUF_X32%VDD_67 N_VDD_M9_d 0.230714
R_x_PM_BUF_X32%VDD_r177 x_PM_BUF_X32%VDD_66 x_PM_BUF_X32%VDD_198 0.0731438
R_x_PM_BUF_X32%VDD_r178 x_PM_BUF_X32%VDD_65 x_PM_BUF_X32%VDD_199 0.0731438
R_x_PM_BUF_X32%VDD_r179 x_PM_BUF_X32%VDD_65 x_PM_BUF_X32%VDD_66 0.692941
R_x_PM_BUF_X32%VDD_r180 x_PM_BUF_X32%VDD_61 x_PM_BUF_X32%VDD_198 0.145286
R_x_PM_BUF_X32%VDD_r181 x_PM_BUF_X32%VDD_61 N_VDD_M7_d 0.230714
R_x_PM_BUF_X32%VDD_r182 x_PM_BUF_X32%VDD_60 x_PM_BUF_X32%VDD_197 0.0731438
R_x_PM_BUF_X32%VDD_r183 x_PM_BUF_X32%VDD_59 x_PM_BUF_X32%VDD_198 0.0731438
R_x_PM_BUF_X32%VDD_r184 x_PM_BUF_X32%VDD_59 x_PM_BUF_X32%VDD_60 0.692941
R_x_PM_BUF_X32%VDD_r185 x_PM_BUF_X32%VDD_55 x_PM_BUF_X32%VDD_197 0.145286
R_x_PM_BUF_X32%VDD_r186 x_PM_BUF_X32%VDD_55 N_VDD_M5_d 0.230714
R_x_PM_BUF_X32%VDD_r187 x_PM_BUF_X32%VDD_54 x_PM_BUF_X32%VDD_196 0.0731438
R_x_PM_BUF_X32%VDD_r188 x_PM_BUF_X32%VDD_53 x_PM_BUF_X32%VDD_197 0.0731438
R_x_PM_BUF_X32%VDD_r189 x_PM_BUF_X32%VDD_53 x_PM_BUF_X32%VDD_54 0.692941
R_x_PM_BUF_X32%VDD_r190 x_PM_BUF_X32%VDD_49 x_PM_BUF_X32%VDD_196 0.145286
R_x_PM_BUF_X32%VDD_r191 x_PM_BUF_X32%VDD_49 N_VDD_M3_d 0.230714
R_x_PM_BUF_X32%VDD_r192 x_PM_BUF_X32%VDD_48 x_PM_BUF_X32%VDD_195 0.0731438
R_x_PM_BUF_X32%VDD_r193 x_PM_BUF_X32%VDD_47 x_PM_BUF_X32%VDD_196 0.0731438
R_x_PM_BUF_X32%VDD_r194 x_PM_BUF_X32%VDD_47 x_PM_BUF_X32%VDD_48 0.692941
R_x_PM_BUF_X32%VDD_r195 x_PM_BUF_X32%VDD_43 x_PM_BUF_X32%VDD_195 0.145286
R_x_PM_BUF_X32%VDD_r196 x_PM_BUF_X32%VDD_43 N_VDD_M1_d 0.230714
R_x_PM_BUF_X32%VDD_r197 x_PM_BUF_X32%VDD_42 x_PM_BUF_X32%VDD_194 0.0752999
R_x_PM_BUF_X32%VDD_r198 x_PM_BUF_X32%VDD_41 x_PM_BUF_X32%VDD_195 0.0731438
R_x_PM_BUF_X32%VDD_r199 x_PM_BUF_X32%VDD_41 x_PM_BUF_X32%VDD_42 0.681765
R_x_PM_BUF_X32%VDD_r200 x_PM_BUF_X32%VDD_194 N_VDD_M0_s 0.230714
R_x_PM_BUF_X32%VDD_r201 x_PM_BUF_X32%VDD_36 VDD 0.140282
R_x_PM_BUF_X32%VDD_r202 x_PM_BUF_X32%VDD_35 VDD 0.143516
R_x_PM_BUF_X32%VDD_r203 x_PM_BUF_X32%VDD_35 x_PM_BUF_X32%VDD_36 7.68941
R_x_PM_BUF_X32%VDD_r204 x_PM_BUF_X32%VDD_32 VDD 18.4971
C_x_PM_BUF_X32%VSS_c0 VSS VSS 2.71247e-16
C_x_PM_BUF_X32%VSS_c1 x_PM_BUF_X32%VSS_218 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c2 x_PM_BUF_X32%VSS_217 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c3 x_PM_BUF_X32%VSS_216 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c4 x_PM_BUF_X32%VSS_215 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c5 x_PM_BUF_X32%VSS_214 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c6 x_PM_BUF_X32%VSS_213 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c7 x_PM_BUF_X32%VSS_212 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c8 x_PM_BUF_X32%VSS_211 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c9 x_PM_BUF_X32%VSS_210 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c10 x_PM_BUF_X32%VSS_209 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c11 x_PM_BUF_X32%VSS_208 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c12 x_PM_BUF_X32%VSS_206 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c13 x_PM_BUF_X32%VSS_205 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c14 x_PM_BUF_X32%VSS_204 VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c15 x_PM_BUF_X32%VSS_203 VSS 2.67225e-18
C_x_PM_BUF_X32%VSS_c16 x_PM_BUF_X32%VSS_202 VSS 2.72111e-18
C_x_PM_BUF_X32%VSS_c17 x_PM_BUF_X32%VSS_201 VSS 2.72111e-18
C_x_PM_BUF_X32%VSS_c18 x_PM_BUF_X32%VSS_200 VSS 2.72111e-18
C_x_PM_BUF_X32%VSS_c19 x_PM_BUF_X32%VSS_199 VSS 2.72111e-18
C_x_PM_BUF_X32%VSS_c20 x_PM_BUF_X32%VSS_198 VSS 2.72111e-18
C_x_PM_BUF_X32%VSS_c21 x_PM_BUF_X32%VSS_197 VSS 2.72111e-18
C_x_PM_BUF_X32%VSS_c22 x_PM_BUF_X32%VSS_196 VSS 2.72111e-18
C_x_PM_BUF_X32%VSS_c23 N_VSS_M95_d VSS 1.07796e-17
C_x_PM_BUF_X32%VSS_c24 x_PM_BUF_X32%VSS_181 VSS 4.18491e-17
C_x_PM_BUF_X32%VSS_c25 N_VSS_M93_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c26 x_PM_BUF_X32%VSS_175 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c27 N_VSS_M91_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c28 x_PM_BUF_X32%VSS_169 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c29 N_VSS_M89_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c30 x_PM_BUF_X32%VSS_163 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c31 N_VSS_M87_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c32 x_PM_BUF_X32%VSS_157 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c33 N_VSS_M85_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c34 x_PM_BUF_X32%VSS_151 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c35 N_VSS_M83_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c36 x_PM_BUF_X32%VSS_145 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c37 N_VSS_M81_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c38 x_PM_BUF_X32%VSS_139 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c39 N_VSS_M79_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c40 x_PM_BUF_X32%VSS_133 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c41 N_VSS_M77_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c42 x_PM_BUF_X32%VSS_127 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c43 N_VSS_M75_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c44 x_PM_BUF_X32%VSS_121 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c45 N_VSS_M73_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c46 x_PM_BUF_X32%VSS_115 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c47 N_VSS_M71_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c48 VSS VSS 2.66251e-18
C_x_PM_BUF_X32%VSS_c49 x_PM_BUF_X32%VSS_107 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c50 N_VSS_M69_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c51 x_PM_BUF_X32%VSS_101 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c52 N_VSS_M67_d VSS 2.38443e-17
C_x_PM_BUF_X32%VSS_c53 x_PM_BUF_X32%VSS_95 VSS 4.45786e-17
C_x_PM_BUF_X32%VSS_c54 N_VSS_M65_d VSS 2.43027e-17
C_x_PM_BUF_X32%VSS_c55 x_PM_BUF_X32%VSS_89 VSS 4.3476e-17
C_x_PM_BUF_X32%VSS_c56 N_VSS_M63_d VSS 1.8708e-17
C_x_PM_BUF_X32%VSS_c57 x_PM_BUF_X32%VSS_83 VSS 3.57041e-17
C_x_PM_BUF_X32%VSS_c58 N_VSS_M61_d VSS 5.22112e-17
C_x_PM_BUF_X32%VSS_c59 x_PM_BUF_X32%VSS_77 VSS 3.48613e-17
C_x_PM_BUF_X32%VSS_c60 N_VSS_M59_d VSS 5.35572e-17
C_x_PM_BUF_X32%VSS_c61 x_PM_BUF_X32%VSS_71 VSS 3.4863e-17
C_x_PM_BUF_X32%VSS_c62 N_VSS_M57_d VSS 5.29132e-17
C_x_PM_BUF_X32%VSS_c63 x_PM_BUF_X32%VSS_65 VSS 3.48613e-17
C_x_PM_BUF_X32%VSS_c64 N_VSS_M55_d VSS 5.21967e-17
C_x_PM_BUF_X32%VSS_c65 x_PM_BUF_X32%VSS_59 VSS 3.48681e-17
C_x_PM_BUF_X32%VSS_c66 N_VSS_M53_d VSS 5.28407e-17
C_x_PM_BUF_X32%VSS_c67 x_PM_BUF_X32%VSS_53 VSS 3.48504e-17
C_x_PM_BUF_X32%VSS_c68 N_VSS_M51_d VSS 5.28407e-17
C_x_PM_BUF_X32%VSS_c69 x_PM_BUF_X32%VSS_47 VSS 3.48686e-17
C_x_PM_BUF_X32%VSS_c70 N_VSS_M49_d VSS 5.43445e-17
C_x_PM_BUF_X32%VSS_c71 x_PM_BUF_X32%VSS_42 VSS 1.89724e-17
C_x_PM_BUF_X32%VSS_c72 x_PM_BUF_X32%VSS_41 VSS 3.48479e-17
C_x_PM_BUF_X32%VSS_c73 N_VSS_M48_s VSS 2.87827e-17
C_x_PM_BUF_X32%VSS_c74 x_PM_BUF_X32%VSS_34 VSS 1.15638e-15
C_x_PM_BUF_X32%VSS_c75 x_PM_BUF_X32%VSS_33 VSS 1.92462e-17
C_x_PM_BUF_X32%VSS_c76 x_PM_BUF_X32%VSS_32 VSS 2.334e-16
R_x_PM_BUF_X32%VSS_r77 x_PM_BUF_X32%VSS_219 VSS 0.436117
R_x_PM_BUF_X32%VSS_r78 VSS x_PM_BUF_X32%VSS_195 0.392137
R_x_PM_BUF_X32%VSS_r79 x_PM_BUF_X32%VSS_219 N_VSS_M95_d 0.257857
R_x_PM_BUF_X32%VSS_r80 x_PM_BUF_X32%VSS_182 x_PM_BUF_X32%VSS_218 0.0731438
R_x_PM_BUF_X32%VSS_r81 x_PM_BUF_X32%VSS_181 x_PM_BUF_X32%VSS_219 0.0753891
R_x_PM_BUF_X32%VSS_r82 x_PM_BUF_X32%VSS_181 x_PM_BUF_X32%VSS_182 0.692941
R_x_PM_BUF_X32%VSS_r83 x_PM_BUF_X32%VSS_177 x_PM_BUF_X32%VSS_218 0.145286
R_x_PM_BUF_X32%VSS_r84 x_PM_BUF_X32%VSS_177 N_VSS_M93_d 0.257857
R_x_PM_BUF_X32%VSS_r85 x_PM_BUF_X32%VSS_176 x_PM_BUF_X32%VSS_217 0.0731438
R_x_PM_BUF_X32%VSS_r86 x_PM_BUF_X32%VSS_175 x_PM_BUF_X32%VSS_218 0.0731438
R_x_PM_BUF_X32%VSS_r87 x_PM_BUF_X32%VSS_175 x_PM_BUF_X32%VSS_176 0.692941
R_x_PM_BUF_X32%VSS_r88 x_PM_BUF_X32%VSS_171 x_PM_BUF_X32%VSS_217 0.145286
R_x_PM_BUF_X32%VSS_r89 x_PM_BUF_X32%VSS_171 N_VSS_M91_d 0.257857
R_x_PM_BUF_X32%VSS_r90 x_PM_BUF_X32%VSS_170 x_PM_BUF_X32%VSS_216 0.0731438
R_x_PM_BUF_X32%VSS_r91 x_PM_BUF_X32%VSS_169 x_PM_BUF_X32%VSS_217 0.0731438
R_x_PM_BUF_X32%VSS_r92 x_PM_BUF_X32%VSS_169 x_PM_BUF_X32%VSS_170 0.692941
R_x_PM_BUF_X32%VSS_r93 x_PM_BUF_X32%VSS_165 x_PM_BUF_X32%VSS_216 0.145286
R_x_PM_BUF_X32%VSS_r94 x_PM_BUF_X32%VSS_165 N_VSS_M89_d 0.257857
R_x_PM_BUF_X32%VSS_r95 x_PM_BUF_X32%VSS_164 x_PM_BUF_X32%VSS_215 0.0731438
R_x_PM_BUF_X32%VSS_r96 x_PM_BUF_X32%VSS_163 x_PM_BUF_X32%VSS_216 0.0731438
R_x_PM_BUF_X32%VSS_r97 x_PM_BUF_X32%VSS_163 x_PM_BUF_X32%VSS_164 0.692941
R_x_PM_BUF_X32%VSS_r98 x_PM_BUF_X32%VSS_159 x_PM_BUF_X32%VSS_215 0.145286
R_x_PM_BUF_X32%VSS_r99 x_PM_BUF_X32%VSS_159 N_VSS_M87_d 0.257857
R_x_PM_BUF_X32%VSS_r100 x_PM_BUF_X32%VSS_158 x_PM_BUF_X32%VSS_214 0.0731438
R_x_PM_BUF_X32%VSS_r101 x_PM_BUF_X32%VSS_157 x_PM_BUF_X32%VSS_215 0.0731438
R_x_PM_BUF_X32%VSS_r102 x_PM_BUF_X32%VSS_157 x_PM_BUF_X32%VSS_158 0.692941
R_x_PM_BUF_X32%VSS_r103 x_PM_BUF_X32%VSS_153 x_PM_BUF_X32%VSS_214 0.145286
R_x_PM_BUF_X32%VSS_r104 x_PM_BUF_X32%VSS_153 N_VSS_M85_d 0.257857
R_x_PM_BUF_X32%VSS_r105 x_PM_BUF_X32%VSS_152 x_PM_BUF_X32%VSS_213 0.0731438
R_x_PM_BUF_X32%VSS_r106 x_PM_BUF_X32%VSS_151 x_PM_BUF_X32%VSS_214 0.0731438
R_x_PM_BUF_X32%VSS_r107 x_PM_BUF_X32%VSS_151 x_PM_BUF_X32%VSS_152 0.692941
R_x_PM_BUF_X32%VSS_r108 x_PM_BUF_X32%VSS_147 x_PM_BUF_X32%VSS_213 0.145286
R_x_PM_BUF_X32%VSS_r109 x_PM_BUF_X32%VSS_147 N_VSS_M83_d 0.257857
R_x_PM_BUF_X32%VSS_r110 x_PM_BUF_X32%VSS_146 x_PM_BUF_X32%VSS_212 0.0731438
R_x_PM_BUF_X32%VSS_r111 x_PM_BUF_X32%VSS_145 x_PM_BUF_X32%VSS_213 0.0731438
R_x_PM_BUF_X32%VSS_r112 x_PM_BUF_X32%VSS_145 x_PM_BUF_X32%VSS_146 0.692941
R_x_PM_BUF_X32%VSS_r113 x_PM_BUF_X32%VSS_141 x_PM_BUF_X32%VSS_212 0.145286
R_x_PM_BUF_X32%VSS_r114 x_PM_BUF_X32%VSS_141 N_VSS_M81_d 0.257857
R_x_PM_BUF_X32%VSS_r115 x_PM_BUF_X32%VSS_140 x_PM_BUF_X32%VSS_211 0.0731438
R_x_PM_BUF_X32%VSS_r116 x_PM_BUF_X32%VSS_139 x_PM_BUF_X32%VSS_212 0.0731438
R_x_PM_BUF_X32%VSS_r117 x_PM_BUF_X32%VSS_139 x_PM_BUF_X32%VSS_140 0.692941
R_x_PM_BUF_X32%VSS_r118 x_PM_BUF_X32%VSS_135 x_PM_BUF_X32%VSS_211 0.145286
R_x_PM_BUF_X32%VSS_r119 x_PM_BUF_X32%VSS_135 N_VSS_M79_d 0.257857
R_x_PM_BUF_X32%VSS_r120 x_PM_BUF_X32%VSS_134 x_PM_BUF_X32%VSS_210 0.0731438
R_x_PM_BUF_X32%VSS_r121 x_PM_BUF_X32%VSS_133 x_PM_BUF_X32%VSS_211 0.0731438
R_x_PM_BUF_X32%VSS_r122 x_PM_BUF_X32%VSS_133 x_PM_BUF_X32%VSS_134 0.692941
R_x_PM_BUF_X32%VSS_r123 x_PM_BUF_X32%VSS_129 x_PM_BUF_X32%VSS_210 0.145286
R_x_PM_BUF_X32%VSS_r124 x_PM_BUF_X32%VSS_129 N_VSS_M77_d 0.257857
R_x_PM_BUF_X32%VSS_r125 x_PM_BUF_X32%VSS_128 x_PM_BUF_X32%VSS_209 0.0731438
R_x_PM_BUF_X32%VSS_r126 x_PM_BUF_X32%VSS_127 x_PM_BUF_X32%VSS_210 0.0731438
R_x_PM_BUF_X32%VSS_r127 x_PM_BUF_X32%VSS_127 x_PM_BUF_X32%VSS_128 0.692941
R_x_PM_BUF_X32%VSS_r128 x_PM_BUF_X32%VSS_123 x_PM_BUF_X32%VSS_209 0.145286
R_x_PM_BUF_X32%VSS_r129 x_PM_BUF_X32%VSS_123 N_VSS_M75_d 0.257857
R_x_PM_BUF_X32%VSS_r130 x_PM_BUF_X32%VSS_122 x_PM_BUF_X32%VSS_208 0.0731438
R_x_PM_BUF_X32%VSS_r131 x_PM_BUF_X32%VSS_121 x_PM_BUF_X32%VSS_209 0.0731438
R_x_PM_BUF_X32%VSS_r132 x_PM_BUF_X32%VSS_121 x_PM_BUF_X32%VSS_122 0.692941
R_x_PM_BUF_X32%VSS_r133 x_PM_BUF_X32%VSS_117 x_PM_BUF_X32%VSS_208 0.145286
R_x_PM_BUF_X32%VSS_r134 x_PM_BUF_X32%VSS_117 N_VSS_M73_d 0.257857
R_x_PM_BUF_X32%VSS_r135 x_PM_BUF_X32%VSS_115 x_PM_BUF_X32%VSS_208 0.0731438
R_x_PM_BUF_X32%VSS_r136 x_PM_BUF_X32%VSS_115 x_PM_BUF_X32%VSS_116 0.692941
R_x_PM_BUF_X32%VSS_r137 VSS N_VSS_M71_d 0.257857
R_x_PM_BUF_X32%VSS_r138 x_PM_BUF_X32%VSS_116 VSS 0.0731438
R_x_PM_BUF_X32%VSS_r139 x_PM_BUF_X32%VSS_108 x_PM_BUF_X32%VSS_206 0.0731438
R_x_PM_BUF_X32%VSS_r140 x_PM_BUF_X32%VSS_107 VSS 0.0731438
R_x_PM_BUF_X32%VSS_r141 x_PM_BUF_X32%VSS_107 x_PM_BUF_X32%VSS_108 0.692941
R_x_PM_BUF_X32%VSS_r142 x_PM_BUF_X32%VSS_103 x_PM_BUF_X32%VSS_206 0.145286
R_x_PM_BUF_X32%VSS_r143 x_PM_BUF_X32%VSS_103 N_VSS_M69_d 0.257857
R_x_PM_BUF_X32%VSS_r144 x_PM_BUF_X32%VSS_102 x_PM_BUF_X32%VSS_205 0.0731438
R_x_PM_BUF_X32%VSS_r145 x_PM_BUF_X32%VSS_101 x_PM_BUF_X32%VSS_206 0.0731438
R_x_PM_BUF_X32%VSS_r146 x_PM_BUF_X32%VSS_101 x_PM_BUF_X32%VSS_102 0.692941
R_x_PM_BUF_X32%VSS_r147 x_PM_BUF_X32%VSS_97 x_PM_BUF_X32%VSS_205 0.145286
R_x_PM_BUF_X32%VSS_r148 x_PM_BUF_X32%VSS_97 N_VSS_M67_d 0.257857
R_x_PM_BUF_X32%VSS_r149 x_PM_BUF_X32%VSS_96 x_PM_BUF_X32%VSS_204 0.0731438
R_x_PM_BUF_X32%VSS_r150 x_PM_BUF_X32%VSS_95 x_PM_BUF_X32%VSS_205 0.0731438
R_x_PM_BUF_X32%VSS_r151 x_PM_BUF_X32%VSS_95 x_PM_BUF_X32%VSS_96 0.692941
R_x_PM_BUF_X32%VSS_r152 x_PM_BUF_X32%VSS_91 x_PM_BUF_X32%VSS_204 0.145286
R_x_PM_BUF_X32%VSS_r153 x_PM_BUF_X32%VSS_91 N_VSS_M65_d 0.257857
R_x_PM_BUF_X32%VSS_r154 x_PM_BUF_X32%VSS_90 x_PM_BUF_X32%VSS_203 0.0731438
R_x_PM_BUF_X32%VSS_r155 x_PM_BUF_X32%VSS_89 x_PM_BUF_X32%VSS_204 0.0731438
R_x_PM_BUF_X32%VSS_r156 x_PM_BUF_X32%VSS_89 x_PM_BUF_X32%VSS_90 0.737647
R_x_PM_BUF_X32%VSS_r157 x_PM_BUF_X32%VSS_85 x_PM_BUF_X32%VSS_203 0.145286
R_x_PM_BUF_X32%VSS_r158 x_PM_BUF_X32%VSS_85 N_VSS_M63_d 0.366429
R_x_PM_BUF_X32%VSS_r159 x_PM_BUF_X32%VSS_84 x_PM_BUF_X32%VSS_202 0.0731438
R_x_PM_BUF_X32%VSS_r160 x_PM_BUF_X32%VSS_83 x_PM_BUF_X32%VSS_203 0.0731438
R_x_PM_BUF_X32%VSS_r161 x_PM_BUF_X32%VSS_83 x_PM_BUF_X32%VSS_84 0.704118
R_x_PM_BUF_X32%VSS_r162 x_PM_BUF_X32%VSS_79 x_PM_BUF_X32%VSS_202 0.145286
R_x_PM_BUF_X32%VSS_r163 x_PM_BUF_X32%VSS_79 N_VSS_M61_d 1.01786
R_x_PM_BUF_X32%VSS_r164 x_PM_BUF_X32%VSS_78 x_PM_BUF_X32%VSS_201 0.0731438
R_x_PM_BUF_X32%VSS_r165 x_PM_BUF_X32%VSS_77 x_PM_BUF_X32%VSS_202 0.0731438
R_x_PM_BUF_X32%VSS_r166 x_PM_BUF_X32%VSS_77 x_PM_BUF_X32%VSS_78 0.692941
R_x_PM_BUF_X32%VSS_r167 x_PM_BUF_X32%VSS_73 x_PM_BUF_X32%VSS_201 0.145286
R_x_PM_BUF_X32%VSS_r168 x_PM_BUF_X32%VSS_73 N_VSS_M59_d 1.01786
R_x_PM_BUF_X32%VSS_r169 x_PM_BUF_X32%VSS_72 x_PM_BUF_X32%VSS_200 0.0731438
R_x_PM_BUF_X32%VSS_r170 x_PM_BUF_X32%VSS_71 x_PM_BUF_X32%VSS_201 0.0731438
R_x_PM_BUF_X32%VSS_r171 x_PM_BUF_X32%VSS_71 x_PM_BUF_X32%VSS_72 0.692941
R_x_PM_BUF_X32%VSS_r172 x_PM_BUF_X32%VSS_67 x_PM_BUF_X32%VSS_200 0.145286
R_x_PM_BUF_X32%VSS_r173 x_PM_BUF_X32%VSS_67 N_VSS_M57_d 1.01786
R_x_PM_BUF_X32%VSS_r174 x_PM_BUF_X32%VSS_66 x_PM_BUF_X32%VSS_199 0.0731438
R_x_PM_BUF_X32%VSS_r175 x_PM_BUF_X32%VSS_65 x_PM_BUF_X32%VSS_200 0.0731438
R_x_PM_BUF_X32%VSS_r176 x_PM_BUF_X32%VSS_65 x_PM_BUF_X32%VSS_66 0.692941
R_x_PM_BUF_X32%VSS_r177 x_PM_BUF_X32%VSS_61 x_PM_BUF_X32%VSS_199 0.145286
R_x_PM_BUF_X32%VSS_r178 x_PM_BUF_X32%VSS_61 N_VSS_M55_d 1.01786
R_x_PM_BUF_X32%VSS_r179 x_PM_BUF_X32%VSS_60 x_PM_BUF_X32%VSS_198 0.0731438
R_x_PM_BUF_X32%VSS_r180 x_PM_BUF_X32%VSS_59 x_PM_BUF_X32%VSS_199 0.0731438
R_x_PM_BUF_X32%VSS_r181 x_PM_BUF_X32%VSS_59 x_PM_BUF_X32%VSS_60 0.692941
R_x_PM_BUF_X32%VSS_r182 x_PM_BUF_X32%VSS_55 x_PM_BUF_X32%VSS_198 0.145286
R_x_PM_BUF_X32%VSS_r183 x_PM_BUF_X32%VSS_55 N_VSS_M53_d 1.01786
R_x_PM_BUF_X32%VSS_r184 x_PM_BUF_X32%VSS_54 x_PM_BUF_X32%VSS_197 0.0731438
R_x_PM_BUF_X32%VSS_r185 x_PM_BUF_X32%VSS_53 x_PM_BUF_X32%VSS_198 0.0731438
R_x_PM_BUF_X32%VSS_r186 x_PM_BUF_X32%VSS_53 x_PM_BUF_X32%VSS_54 0.692941
R_x_PM_BUF_X32%VSS_r187 x_PM_BUF_X32%VSS_49 x_PM_BUF_X32%VSS_197 0.145286
R_x_PM_BUF_X32%VSS_r188 x_PM_BUF_X32%VSS_49 N_VSS_M51_d 1.01786
R_x_PM_BUF_X32%VSS_r189 x_PM_BUF_X32%VSS_48 x_PM_BUF_X32%VSS_196 0.0731438
R_x_PM_BUF_X32%VSS_r190 x_PM_BUF_X32%VSS_47 x_PM_BUF_X32%VSS_197 0.0731438
R_x_PM_BUF_X32%VSS_r191 x_PM_BUF_X32%VSS_47 x_PM_BUF_X32%VSS_48 0.692941
R_x_PM_BUF_X32%VSS_r192 x_PM_BUF_X32%VSS_43 x_PM_BUF_X32%VSS_196 0.145286
R_x_PM_BUF_X32%VSS_r193 x_PM_BUF_X32%VSS_43 N_VSS_M49_d 1.01786
R_x_PM_BUF_X32%VSS_r194 x_PM_BUF_X32%VSS_42 x_PM_BUF_X32%VSS_195 0.0752999
R_x_PM_BUF_X32%VSS_r195 x_PM_BUF_X32%VSS_41 x_PM_BUF_X32%VSS_196 0.0731438
R_x_PM_BUF_X32%VSS_r196 x_PM_BUF_X32%VSS_41 x_PM_BUF_X32%VSS_42 0.681765
R_x_PM_BUF_X32%VSS_r197 x_PM_BUF_X32%VSS_195 N_VSS_M48_s 1.12643
R_x_PM_BUF_X32%VSS_r198 x_PM_BUF_X32%VSS_34 VSS 18.4971
R_x_PM_BUF_X32%VSS_r199 x_PM_BUF_X32%VSS_33 VSS 0.140282
R_x_PM_BUF_X32%VSS_r200 x_PM_BUF_X32%VSS_32 VSS 0.143516
R_x_PM_BUF_X32%VSS_r201 x_PM_BUF_X32%VSS_32 x_PM_BUF_X32%VSS_33 7.68941
C_x_PM_BUF_X32%A_c0 x_PM_BUF_X32%A_203 VSS 1.91615e-17
C_x_PM_BUF_X32%A_c1 x_PM_BUF_X32%A_202 VSS 1.84356e-17
C_x_PM_BUF_X32%A_c2 x_PM_BUF_X32%A_198 VSS 1.13739e-16
C_x_PM_BUF_X32%A_c3 x_PM_BUF_X32%A_195 VSS 7.76893e-17
C_x_PM_BUF_X32%A_c4 x_PM_BUF_X32%A_189 VSS 1.09808e-16
C_x_PM_BUF_X32%A_c5 x_PM_BUF_X32%A_186 VSS 5.66863e-17
C_x_PM_BUF_X32%A_c6 x_PM_BUF_X32%A_182 VSS 1.21666e-16
C_x_PM_BUF_X32%A_c7 x_PM_BUF_X32%A_180 VSS 5.73708e-18
C_x_PM_BUF_X32%A_c8 x_PM_BUF_X32%A_179 VSS 9.20203e-17
C_x_PM_BUF_X32%A_c9 x_PM_BUF_X32%A_175 VSS 6.40933e-17
C_x_PM_BUF_X32%A_c10 x_PM_BUF_X32%A_173 VSS 4.30545e-18
C_x_PM_BUF_X32%A_c11 x_PM_BUF_X32%A_172 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c12 x_PM_BUF_X32%A_171 VSS 6.58816e-18
C_x_PM_BUF_X32%A_c13 x_PM_BUF_X32%A_170 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c14 x_PM_BUF_X32%A_168 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c15 x_PM_BUF_X32%A_167 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c16 x_PM_BUF_X32%A_166 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c17 x_PM_BUF_X32%A_165 VSS 6.58816e-18
C_x_PM_BUF_X32%A_c18 x_PM_BUF_X32%A_164 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c19 x_PM_BUF_X32%A_162 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c20 x_PM_BUF_X32%A_161 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c21 x_PM_BUF_X32%A_160 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c22 x_PM_BUF_X32%A_159 VSS 6.58816e-18
C_x_PM_BUF_X32%A_c23 x_PM_BUF_X32%A_158 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c24 x_PM_BUF_X32%A_156 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c25 x_PM_BUF_X32%A_155 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c26 x_PM_BUF_X32%A_154 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c27 x_PM_BUF_X32%A_153 VSS 6.72026e-19
C_x_PM_BUF_X32%A_c28 N_A_M15_g VSS 5.17036e-17
C_x_PM_BUF_X32%A_c29 N_A_M63_g VSS 4.36087e-17
C_x_PM_BUF_X32%A_c30 x_PM_BUF_X32%A_143 VSS 1.21574e-17
C_x_PM_BUF_X32%A_c31 N_A_M14_g VSS 3.23629e-17
C_x_PM_BUF_X32%A_c32 N_A_M62_g VSS 2.96876e-17
C_x_PM_BUF_X32%A_c33 N_A_M13_g VSS 3.07345e-17
C_x_PM_BUF_X32%A_c34 N_A_M61_g VSS 2.96074e-17
C_x_PM_BUF_X32%A_c35 x_PM_BUF_X32%A_125 VSS 1.18029e-17
C_x_PM_BUF_X32%A_c36 N_A_M12_g VSS 3.19485e-17
C_x_PM_BUF_X32%A_c37 N_A_M60_g VSS 2.9118e-17
C_x_PM_BUF_X32%A_c38 x_PM_BUF_X32%A_115 VSS 7.14172e-18
C_x_PM_BUF_X32%A_c39 N_A_M11_g VSS 3.16714e-17
C_x_PM_BUF_X32%A_c40 N_A_M59_g VSS 2.91136e-17
C_x_PM_BUF_X32%A_c41 x_PM_BUF_X32%A_105 VSS 1.18341e-17
C_x_PM_BUF_X32%A_c42 N_A_M10_g VSS 3.14818e-17
C_x_PM_BUF_X32%A_c43 N_A_M58_g VSS 2.95589e-17
C_x_PM_BUF_X32%A_c44 N_A_M9_g VSS 3.0708e-17
C_x_PM_BUF_X32%A_c45 N_A_M57_g VSS 2.9452e-17
C_x_PM_BUF_X32%A_c46 x_PM_BUF_X32%A_87 VSS 1.18096e-17
C_x_PM_BUF_X32%A_c47 N_A_M8_g VSS 3.19394e-17
C_x_PM_BUF_X32%A_c48 N_A_M56_g VSS 2.92797e-17
C_x_PM_BUF_X32%A_c49 x_PM_BUF_X32%A_77 VSS 7.14172e-18
C_x_PM_BUF_X32%A_c50 N_A_M7_g VSS 3.16473e-17
C_x_PM_BUF_X32%A_c51 N_A_M55_g VSS 2.94127e-17
C_x_PM_BUF_X32%A_c52 x_PM_BUF_X32%A_67 VSS 1.18385e-17
C_x_PM_BUF_X32%A_c53 N_A_M6_g VSS 3.15066e-17
C_x_PM_BUF_X32%A_c54 N_A_M54_g VSS 2.92037e-17
C_x_PM_BUF_X32%A_c55 N_A_M5_g VSS 3.07136e-17
C_x_PM_BUF_X32%A_c56 N_A_M53_g VSS 2.92779e-17
C_x_PM_BUF_X32%A_c57 x_PM_BUF_X32%A_49 VSS 1.17534e-17
C_x_PM_BUF_X32%A_c58 N_A_M4_g VSS 3.19578e-17
C_x_PM_BUF_X32%A_c59 N_A_M52_g VSS 2.91038e-17
C_x_PM_BUF_X32%A_c60 x_PM_BUF_X32%A_39 VSS 7.14172e-18
C_x_PM_BUF_X32%A_c61 N_A_M3_g VSS 3.16963e-17
C_x_PM_BUF_X32%A_c62 N_A_M51_g VSS 2.91747e-17
C_x_PM_BUF_X32%A_c63 x_PM_BUF_X32%A_29 VSS 1.20501e-17
C_x_PM_BUF_X32%A_c64 N_A_M2_g VSS 3.19088e-17
C_x_PM_BUF_X32%A_c65 N_A_M50_g VSS 2.94286e-17
C_x_PM_BUF_X32%A_c66 x_PM_BUF_X32%A_19 VSS 7.14172e-18
C_x_PM_BUF_X32%A_c67 N_A_M1_g VSS 3.16876e-17
C_x_PM_BUF_X32%A_c68 N_A_M49_g VSS 2.8627e-17
C_x_PM_BUF_X32%A_c69 x_PM_BUF_X32%A_10 VSS 4.303e-18
C_x_PM_BUF_X32%A_c70 x_PM_BUF_X32%A_9 VSS 1.1745e-17
C_x_PM_BUF_X32%A_c71 N_A_M0_g VSS 4.65148e-17
C_x_PM_BUF_X32%A_c72 N_A_M48_g VSS 4.13913e-17
R_x_PM_BUF_X32%A_r73 x_PM_BUF_X32%A_198 x_PM_BUF_X32%A_200 25.0012
R_x_PM_BUF_X32%A_r74 x_PM_BUF_X32%A_197 x_PM_BUF_X32%A_198 0.95
R_x_PM_BUF_X32%A_r75 x_PM_BUF_X32%A_196 x_PM_BUF_X32%A_203 0.266978
R_x_PM_BUF_X32%A_r76 x_PM_BUF_X32%A_195 x_PM_BUF_X32%A_197 0.241334
R_x_PM_BUF_X32%A_r77 x_PM_BUF_X32%A_195 x_PM_BUF_X32%A_196 3.39286
R_x_PM_BUF_X32%A_r78 x_PM_BUF_X32%A_189 x_PM_BUF_X32%A_191 25.0012
R_x_PM_BUF_X32%A_r79 x_PM_BUF_X32%A_189 A 0.49963
R_x_PM_BUF_X32%A_r80 x_PM_BUF_X32%A_188 x_PM_BUF_X32%A_203 0.0272847
R_x_PM_BUF_X32%A_r81 x_PM_BUF_X32%A_188 A 0.45037
R_x_PM_BUF_X32%A_r82 x_PM_BUF_X32%A_187 x_PM_BUF_X32%A_202 0.266978
R_x_PM_BUF_X32%A_r83 x_PM_BUF_X32%A_186 x_PM_BUF_X32%A_203 0.266978
R_x_PM_BUF_X32%A_r84 x_PM_BUF_X32%A_186 x_PM_BUF_X32%A_187 3.52857
R_x_PM_BUF_X32%A_r85 x_PM_BUF_X32%A_182 x_PM_BUF_X32%A_184 25.0012
R_x_PM_BUF_X32%A_r86 x_PM_BUF_X32%A_181 x_PM_BUF_X32%A_202 0.0272847
R_x_PM_BUF_X32%A_r87 x_PM_BUF_X32%A_181 x_PM_BUF_X32%A_182 0.95
R_x_PM_BUF_X32%A_r88 x_PM_BUF_X32%A_179 x_PM_BUF_X32%A_202 0.266978
R_x_PM_BUF_X32%A_r89 x_PM_BUF_X32%A_179 x_PM_BUF_X32%A_180 5.15714
R_x_PM_BUF_X32%A_r90 x_PM_BUF_X32%A_177 x_PM_BUF_X32%A_209 3.38
R_x_PM_BUF_X32%A_r91 x_PM_BUF_X32%A_175 x_PM_BUF_X32%A_177 25.0012
R_x_PM_BUF_X32%A_r92 x_PM_BUF_X32%A_174 x_PM_BUF_X32%A_180 0.212317
R_x_PM_BUF_X32%A_r93 x_PM_BUF_X32%A_174 x_PM_BUF_X32%A_175 1.83214
R_x_PM_BUF_X32%A_r94 x_PM_BUF_X32%A_171 x_PM_BUF_X32%A_200 7.54
R_x_PM_BUF_X32%A_r95 x_PM_BUF_X32%A_171 x_PM_BUF_X32%A_172 1.95
R_x_PM_BUF_X32%A_r96 x_PM_BUF_X32%A_169 x_PM_BUF_X32%A_200 7.02
R_x_PM_BUF_X32%A_r97 x_PM_BUF_X32%A_169 x_PM_BUF_X32%A_170 1.95
R_x_PM_BUF_X32%A_r98 x_PM_BUF_X32%A_165 x_PM_BUF_X32%A_191 7.54
R_x_PM_BUF_X32%A_r99 x_PM_BUF_X32%A_165 x_PM_BUF_X32%A_166 1.95
R_x_PM_BUF_X32%A_r100 x_PM_BUF_X32%A_163 x_PM_BUF_X32%A_191 7.02
R_x_PM_BUF_X32%A_r101 x_PM_BUF_X32%A_163 x_PM_BUF_X32%A_164 1.95
R_x_PM_BUF_X32%A_r102 x_PM_BUF_X32%A_159 x_PM_BUF_X32%A_184 10.14
R_x_PM_BUF_X32%A_r103 x_PM_BUF_X32%A_159 x_PM_BUF_X32%A_160 1.95
R_x_PM_BUF_X32%A_r104 x_PM_BUF_X32%A_157 x_PM_BUF_X32%A_184 4.42
R_x_PM_BUF_X32%A_r105 x_PM_BUF_X32%A_157 x_PM_BUF_X32%A_158 1.95
R_x_PM_BUF_X32%A_r106 x_PM_BUF_X32%A_149 x_PM_BUF_X32%A_173 4.56151
R_x_PM_BUF_X32%A_r107 x_PM_BUF_X32%A_149 N_A_M15_g 56.94
R_x_PM_BUF_X32%A_r108 x_PM_BUF_X32%A_145 x_PM_BUF_X32%A_173 4.56151
R_x_PM_BUF_X32%A_r109 x_PM_BUF_X32%A_145 N_A_M63_g 40.17
R_x_PM_BUF_X32%A_r110 x_PM_BUF_X32%A_144 x_PM_BUF_X32%A_172 1.95
R_x_PM_BUF_X32%A_r111 x_PM_BUF_X32%A_143 x_PM_BUF_X32%A_173 0.043368
R_x_PM_BUF_X32%A_r112 x_PM_BUF_X32%A_143 x_PM_BUF_X32%A_144 15.08
R_x_PM_BUF_X32%A_r113 x_PM_BUF_X32%A_139 x_PM_BUF_X32%A_172 1.95
R_x_PM_BUF_X32%A_r114 x_PM_BUF_X32%A_139 N_A_M14_g 56.94
R_x_PM_BUF_X32%A_r115 x_PM_BUF_X32%A_135 x_PM_BUF_X32%A_172 1.95
R_x_PM_BUF_X32%A_r116 x_PM_BUF_X32%A_135 N_A_M62_g 40.17
R_x_PM_BUF_X32%A_r117 x_PM_BUF_X32%A_131 x_PM_BUF_X32%A_170 1.95
R_x_PM_BUF_X32%A_r118 x_PM_BUF_X32%A_131 N_A_M13_g 56.94
R_x_PM_BUF_X32%A_r119 x_PM_BUF_X32%A_127 x_PM_BUF_X32%A_170 1.95
R_x_PM_BUF_X32%A_r120 x_PM_BUF_X32%A_127 N_A_M61_g 40.17
R_x_PM_BUF_X32%A_r121 x_PM_BUF_X32%A_126 x_PM_BUF_X32%A_168 1.95
R_x_PM_BUF_X32%A_r122 x_PM_BUF_X32%A_125 x_PM_BUF_X32%A_170 1.95
R_x_PM_BUF_X32%A_r123 x_PM_BUF_X32%A_125 x_PM_BUF_X32%A_126 14.56
R_x_PM_BUF_X32%A_r124 x_PM_BUF_X32%A_121 x_PM_BUF_X32%A_168 1.95
R_x_PM_BUF_X32%A_r125 x_PM_BUF_X32%A_121 N_A_M12_g 56.94
R_x_PM_BUF_X32%A_r126 x_PM_BUF_X32%A_117 x_PM_BUF_X32%A_168 1.95
R_x_PM_BUF_X32%A_r127 x_PM_BUF_X32%A_117 N_A_M60_g 40.17
R_x_PM_BUF_X32%A_r128 x_PM_BUF_X32%A_116 x_PM_BUF_X32%A_167 1.95
R_x_PM_BUF_X32%A_r129 x_PM_BUF_X32%A_115 x_PM_BUF_X32%A_168 1.95
R_x_PM_BUF_X32%A_r130 x_PM_BUF_X32%A_115 x_PM_BUF_X32%A_116 14.56
R_x_PM_BUF_X32%A_r131 x_PM_BUF_X32%A_111 x_PM_BUF_X32%A_167 1.95
R_x_PM_BUF_X32%A_r132 x_PM_BUF_X32%A_111 N_A_M11_g 56.94
R_x_PM_BUF_X32%A_r133 x_PM_BUF_X32%A_107 x_PM_BUF_X32%A_167 1.95
R_x_PM_BUF_X32%A_r134 x_PM_BUF_X32%A_107 N_A_M59_g 40.17
R_x_PM_BUF_X32%A_r135 x_PM_BUF_X32%A_106 x_PM_BUF_X32%A_166 1.95
R_x_PM_BUF_X32%A_r136 x_PM_BUF_X32%A_105 x_PM_BUF_X32%A_167 1.95
R_x_PM_BUF_X32%A_r137 x_PM_BUF_X32%A_105 x_PM_BUF_X32%A_106 14.56
R_x_PM_BUF_X32%A_r138 x_PM_BUF_X32%A_101 x_PM_BUF_X32%A_166 1.95
R_x_PM_BUF_X32%A_r139 x_PM_BUF_X32%A_101 N_A_M10_g 56.94
R_x_PM_BUF_X32%A_r140 x_PM_BUF_X32%A_97 x_PM_BUF_X32%A_166 1.95
R_x_PM_BUF_X32%A_r141 x_PM_BUF_X32%A_97 N_A_M58_g 40.17
R_x_PM_BUF_X32%A_r142 x_PM_BUF_X32%A_93 x_PM_BUF_X32%A_164 1.95
R_x_PM_BUF_X32%A_r143 x_PM_BUF_X32%A_93 N_A_M9_g 56.94
R_x_PM_BUF_X32%A_r144 x_PM_BUF_X32%A_89 x_PM_BUF_X32%A_164 1.95
R_x_PM_BUF_X32%A_r145 x_PM_BUF_X32%A_89 N_A_M57_g 40.17
R_x_PM_BUF_X32%A_r146 x_PM_BUF_X32%A_88 x_PM_BUF_X32%A_162 1.95
R_x_PM_BUF_X32%A_r147 x_PM_BUF_X32%A_87 x_PM_BUF_X32%A_164 1.95
R_x_PM_BUF_X32%A_r148 x_PM_BUF_X32%A_87 x_PM_BUF_X32%A_88 14.56
R_x_PM_BUF_X32%A_r149 x_PM_BUF_X32%A_83 x_PM_BUF_X32%A_162 1.95
R_x_PM_BUF_X32%A_r150 x_PM_BUF_X32%A_83 N_A_M8_g 56.94
R_x_PM_BUF_X32%A_r151 x_PM_BUF_X32%A_79 x_PM_BUF_X32%A_162 1.95
R_x_PM_BUF_X32%A_r152 x_PM_BUF_X32%A_79 N_A_M56_g 40.17
R_x_PM_BUF_X32%A_r153 x_PM_BUF_X32%A_78 x_PM_BUF_X32%A_161 1.95
R_x_PM_BUF_X32%A_r154 x_PM_BUF_X32%A_77 x_PM_BUF_X32%A_162 1.95
R_x_PM_BUF_X32%A_r155 x_PM_BUF_X32%A_77 x_PM_BUF_X32%A_78 14.56
R_x_PM_BUF_X32%A_r156 x_PM_BUF_X32%A_73 x_PM_BUF_X32%A_161 1.95
R_x_PM_BUF_X32%A_r157 x_PM_BUF_X32%A_73 N_A_M7_g 56.94
R_x_PM_BUF_X32%A_r158 x_PM_BUF_X32%A_69 x_PM_BUF_X32%A_161 1.95
R_x_PM_BUF_X32%A_r159 x_PM_BUF_X32%A_69 N_A_M55_g 40.17
R_x_PM_BUF_X32%A_r160 x_PM_BUF_X32%A_68 x_PM_BUF_X32%A_160 1.95
R_x_PM_BUF_X32%A_r161 x_PM_BUF_X32%A_67 x_PM_BUF_X32%A_161 1.95
R_x_PM_BUF_X32%A_r162 x_PM_BUF_X32%A_67 x_PM_BUF_X32%A_68 14.56
R_x_PM_BUF_X32%A_r163 x_PM_BUF_X32%A_63 x_PM_BUF_X32%A_160 1.95
R_x_PM_BUF_X32%A_r164 x_PM_BUF_X32%A_63 N_A_M6_g 56.94
R_x_PM_BUF_X32%A_r165 x_PM_BUF_X32%A_59 x_PM_BUF_X32%A_160 1.95
R_x_PM_BUF_X32%A_r166 x_PM_BUF_X32%A_59 N_A_M54_g 40.17
R_x_PM_BUF_X32%A_r167 x_PM_BUF_X32%A_55 x_PM_BUF_X32%A_158 1.95
R_x_PM_BUF_X32%A_r168 x_PM_BUF_X32%A_55 N_A_M5_g 56.94
R_x_PM_BUF_X32%A_r169 x_PM_BUF_X32%A_51 x_PM_BUF_X32%A_158 1.95
R_x_PM_BUF_X32%A_r170 x_PM_BUF_X32%A_51 N_A_M53_g 40.17
R_x_PM_BUF_X32%A_r171 x_PM_BUF_X32%A_50 x_PM_BUF_X32%A_156 1.95
R_x_PM_BUF_X32%A_r172 x_PM_BUF_X32%A_49 x_PM_BUF_X32%A_158 1.95
R_x_PM_BUF_X32%A_r173 x_PM_BUF_X32%A_49 x_PM_BUF_X32%A_50 14.56
R_x_PM_BUF_X32%A_r174 x_PM_BUF_X32%A_45 x_PM_BUF_X32%A_156 1.95
R_x_PM_BUF_X32%A_r175 x_PM_BUF_X32%A_45 N_A_M4_g 56.94
R_x_PM_BUF_X32%A_r176 x_PM_BUF_X32%A_41 x_PM_BUF_X32%A_156 1.95
R_x_PM_BUF_X32%A_r177 x_PM_BUF_X32%A_41 N_A_M52_g 40.17
R_x_PM_BUF_X32%A_r178 x_PM_BUF_X32%A_40 x_PM_BUF_X32%A_155 1.95
R_x_PM_BUF_X32%A_r179 x_PM_BUF_X32%A_39 x_PM_BUF_X32%A_156 1.95
R_x_PM_BUF_X32%A_r180 x_PM_BUF_X32%A_39 x_PM_BUF_X32%A_40 14.56
R_x_PM_BUF_X32%A_r181 x_PM_BUF_X32%A_35 x_PM_BUF_X32%A_155 1.95
R_x_PM_BUF_X32%A_r182 x_PM_BUF_X32%A_35 N_A_M3_g 56.94
R_x_PM_BUF_X32%A_r183 x_PM_BUF_X32%A_31 x_PM_BUF_X32%A_155 1.95
R_x_PM_BUF_X32%A_r184 x_PM_BUF_X32%A_31 N_A_M51_g 40.17
R_x_PM_BUF_X32%A_r185 x_PM_BUF_X32%A_30 x_PM_BUF_X32%A_154 1.95
R_x_PM_BUF_X32%A_r186 x_PM_BUF_X32%A_29 x_PM_BUF_X32%A_155 1.95
R_x_PM_BUF_X32%A_r187 x_PM_BUF_X32%A_29 x_PM_BUF_X32%A_30 14.56
R_x_PM_BUF_X32%A_r188 x_PM_BUF_X32%A_25 x_PM_BUF_X32%A_154 1.95
R_x_PM_BUF_X32%A_r189 x_PM_BUF_X32%A_25 N_A_M2_g 56.94
R_x_PM_BUF_X32%A_r190 x_PM_BUF_X32%A_21 x_PM_BUF_X32%A_154 1.95
R_x_PM_BUF_X32%A_r191 x_PM_BUF_X32%A_21 N_A_M50_g 40.17
R_x_PM_BUF_X32%A_r192 x_PM_BUF_X32%A_20 x_PM_BUF_X32%A_153 1.95
R_x_PM_BUF_X32%A_r193 x_PM_BUF_X32%A_19 x_PM_BUF_X32%A_154 1.95
R_x_PM_BUF_X32%A_r194 x_PM_BUF_X32%A_19 x_PM_BUF_X32%A_20 14.56
R_x_PM_BUF_X32%A_r195 x_PM_BUF_X32%A_15 x_PM_BUF_X32%A_153 1.95
R_x_PM_BUF_X32%A_r196 x_PM_BUF_X32%A_15 N_A_M1_g 56.94
R_x_PM_BUF_X32%A_r197 x_PM_BUF_X32%A_11 x_PM_BUF_X32%A_153 1.95
R_x_PM_BUF_X32%A_r198 x_PM_BUF_X32%A_11 N_A_M49_g 40.17
R_x_PM_BUF_X32%A_r199 x_PM_BUF_X32%A_10 x_PM_BUF_X32%A_209 2.6
R_x_PM_BUF_X32%A_r200 x_PM_BUF_X32%A_9 x_PM_BUF_X32%A_153 1.95
R_x_PM_BUF_X32%A_r201 x_PM_BUF_X32%A_9 x_PM_BUF_X32%A_10 14.56
R_x_PM_BUF_X32%A_r202 x_PM_BUF_X32%A_5 x_PM_BUF_X32%A_209 1.95
R_x_PM_BUF_X32%A_r203 x_PM_BUF_X32%A_5 N_A_M0_g 56.94
R_x_PM_BUF_X32%A_r204 x_PM_BUF_X32%A_1 x_PM_BUF_X32%A_209 1.95
R_x_PM_BUF_X32%A_r205 x_PM_BUF_X32%A_1 N_A_M48_g 40.17
C_x_PM_BUF_X32%4_c0 x_PM_BUF_X32%4_487 VSS 7.21824e-18
C_x_PM_BUF_X32%4_c1 x_PM_BUF_X32%4_486 VSS 7.21824e-18
C_x_PM_BUF_X32%4_c2 x_PM_BUF_X32%4_485 VSS 7.21824e-18
C_x_PM_BUF_X32%4_c3 x_PM_BUF_X32%4_484 VSS 7.21824e-18
C_x_PM_BUF_X32%4_c4 x_PM_BUF_X32%4_476 VSS 6.80655e-18
C_x_PM_BUF_X32%4_c5 x_PM_BUF_X32%4_475 VSS 7.84993e-17
C_x_PM_BUF_X32%4_c6 x_PM_BUF_X32%4_471 VSS 9.50822e-17
C_x_PM_BUF_X32%4_c7 x_PM_BUF_X32%4_470 VSS 7.35011e-17
C_x_PM_BUF_X32%4_c8 x_PM_BUF_X32%4_466 VSS 7.66062e-17
C_x_PM_BUF_X32%4_c9 x_PM_BUF_X32%4_465 VSS 7.35011e-17
C_x_PM_BUF_X32%4_c10 x_PM_BUF_X32%4_461 VSS 7.66062e-17
C_x_PM_BUF_X32%4_c11 x_PM_BUF_X32%4_460 VSS 7.35011e-17
C_x_PM_BUF_X32%4_c12 x_PM_BUF_X32%4_456 VSS 7.66062e-17
C_x_PM_BUF_X32%4_c13 x_PM_BUF_X32%4_455 VSS 7.35011e-17
C_x_PM_BUF_X32%4_c14 x_PM_BUF_X32%4_452 VSS 4.31453e-18
C_x_PM_BUF_X32%4_c15 x_PM_BUF_X32%4_451 VSS 7.58503e-17
C_x_PM_BUF_X32%4_c16 x_PM_BUF_X32%4_450 VSS 5.15195e-18
C_x_PM_BUF_X32%4_c17 x_PM_BUF_X32%4_448 VSS 4.97266e-17
C_x_PM_BUF_X32%4_c18 x_PM_BUF_X32%4_444 VSS 5.09384e-17
C_x_PM_BUF_X32%4_c19 N_4_M62_d VSS 5.07703e-17
C_x_PM_BUF_X32%4_c20 N_4_M14_d VSS 5.14209e-17
C_x_PM_BUF_X32%4_c21 x_PM_BUF_X32%4_434 VSS 4.86198e-17
C_x_PM_BUF_X32%4_c22 N_4_M12_d VSS 6.69502e-17
C_x_PM_BUF_X32%4_c23 N_4_M60_d VSS 5.47481e-17
C_x_PM_BUF_X32%4_c24 x_PM_BUF_X32%4_424 VSS 2.89326e-17
C_x_PM_BUF_X32%4_c25 N_4_M10_d VSS 6.69597e-17
C_x_PM_BUF_X32%4_c26 N_4_M58_d VSS 5.48069e-17
C_x_PM_BUF_X32%4_c27 x_PM_BUF_X32%4_414 VSS 4.85918e-17
C_x_PM_BUF_X32%4_c28 N_4_M56_d VSS 5.50525e-17
C_x_PM_BUF_X32%4_c29 N_4_M8_d VSS 6.72544e-17
C_x_PM_BUF_X32%4_c30 x_PM_BUF_X32%4_404 VSS 2.95117e-17
C_x_PM_BUF_X32%4_c31 N_4_M6_d VSS 6.14121e-17
C_x_PM_BUF_X32%4_c32 N_4_M54_d VSS 5.4763e-17
C_x_PM_BUF_X32%4_c33 x_PM_BUF_X32%4_394 VSS 4.83471e-17
C_x_PM_BUF_X32%4_c34 N_4_M4_d VSS 8.47491e-17
C_x_PM_BUF_X32%4_c35 N_4_M52_d VSS 5.47486e-17
C_x_PM_BUF_X32%4_c36 x_PM_BUF_X32%4_384 VSS 2.89762e-17
C_x_PM_BUF_X32%4_c37 N_4_M2_d VSS 4.1728e-17
C_x_PM_BUF_X32%4_c38 N_4_M50_d VSS 5.51511e-17
C_x_PM_BUF_X32%4_c39 x_PM_BUF_X32%4_374 VSS 2.8892e-17
C_x_PM_BUF_X32%4_c40 N_4_M0_d VSS 9.09635e-17
C_x_PM_BUF_X32%4_c41 N_4_M48_d VSS 5.83073e-17
C_x_PM_BUF_X32%4_c42 x_PM_BUF_X32%4_349 VSS 3.30952e-18
C_x_PM_BUF_X32%4_c43 x_PM_BUF_X32%4_348 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c44 x_PM_BUF_X32%4_347 VSS 6.19384e-18
C_x_PM_BUF_X32%4_c45 x_PM_BUF_X32%4_346 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c46 x_PM_BUF_X32%4_344 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c47 x_PM_BUF_X32%4_343 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c48 x_PM_BUF_X32%4_342 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c49 x_PM_BUF_X32%4_341 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c50 x_PM_BUF_X32%4_340 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c51 x_PM_BUF_X32%4_339 VSS 6.19384e-18
C_x_PM_BUF_X32%4_c52 x_PM_BUF_X32%4_338 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c53 x_PM_BUF_X32%4_336 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c54 x_PM_BUF_X32%4_335 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c55 x_PM_BUF_X32%4_334 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c56 x_PM_BUF_X32%4_333 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c57 x_PM_BUF_X32%4_332 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c58 x_PM_BUF_X32%4_331 VSS 6.19384e-18
C_x_PM_BUF_X32%4_c59 x_PM_BUF_X32%4_330 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c60 x_PM_BUF_X32%4_328 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c61 x_PM_BUF_X32%4_327 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c62 x_PM_BUF_X32%4_326 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c63 x_PM_BUF_X32%4_325 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c64 x_PM_BUF_X32%4_324 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c65 x_PM_BUF_X32%4_323 VSS 6.19384e-18
C_x_PM_BUF_X32%4_c66 x_PM_BUF_X32%4_322 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c67 x_PM_BUF_X32%4_320 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c68 x_PM_BUF_X32%4_319 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c69 x_PM_BUF_X32%4_318 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c70 x_PM_BUF_X32%4_317 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c71 x_PM_BUF_X32%4_316 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c72 x_PM_BUF_X32%4_315 VSS 6.19384e-18
C_x_PM_BUF_X32%4_c73 x_PM_BUF_X32%4_314 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c74 x_PM_BUF_X32%4_312 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c75 x_PM_BUF_X32%4_311 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c76 x_PM_BUF_X32%4_310 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c77 x_PM_BUF_X32%4_309 VSS 6.72026e-19
C_x_PM_BUF_X32%4_c78 N_4_M47_g VSS 5.33706e-17
C_x_PM_BUF_X32%4_c79 N_4_M95_g VSS 3.81013e-17
C_x_PM_BUF_X32%4_c80 x_PM_BUF_X32%4_299 VSS 1.227e-17
C_x_PM_BUF_X32%4_c81 N_4_M46_g VSS 3.33881e-17
C_x_PM_BUF_X32%4_c82 N_4_M94_g VSS 3.14348e-17
C_x_PM_BUF_X32%4_c83 N_4_M45_g VSS 3.0923e-17
C_x_PM_BUF_X32%4_c84 N_4_M93_g VSS 3.17743e-17
C_x_PM_BUF_X32%4_c85 x_PM_BUF_X32%4_281 VSS 1.17683e-17
C_x_PM_BUF_X32%4_c86 N_4_M44_g VSS 3.16304e-17
C_x_PM_BUF_X32%4_c87 N_4_M92_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c88 x_PM_BUF_X32%4_271 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c89 N_4_M43_g VSS 3.12597e-17
C_x_PM_BUF_X32%4_c90 N_4_M91_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c91 x_PM_BUF_X32%4_261 VSS 1.20951e-17
C_x_PM_BUF_X32%4_c92 N_4_M42_g VSS 3.15162e-17
C_x_PM_BUF_X32%4_c93 N_4_M90_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c94 x_PM_BUF_X32%4_251 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c95 N_4_M41_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c96 N_4_M89_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c97 x_PM_BUF_X32%4_241 VSS 1.18706e-17
C_x_PM_BUF_X32%4_c98 N_4_M40_g VSS 3.11751e-17
C_x_PM_BUF_X32%4_c99 N_4_M88_g VSS 3.17203e-17
C_x_PM_BUF_X32%4_c100 N_4_M39_g VSS 3.0497e-17
C_x_PM_BUF_X32%4_c101 N_4_M87_g VSS 3.17743e-17
C_x_PM_BUF_X32%4_c102 x_PM_BUF_X32%4_223 VSS 1.17662e-17
C_x_PM_BUF_X32%4_c103 N_4_M38_g VSS 3.14605e-17
C_x_PM_BUF_X32%4_c104 N_4_M86_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c105 x_PM_BUF_X32%4_213 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c106 N_4_M37_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c107 N_4_M85_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c108 x_PM_BUF_X32%4_203 VSS 1.20629e-17
C_x_PM_BUF_X32%4_c109 N_4_M36_g VSS 3.14605e-17
C_x_PM_BUF_X32%4_c110 N_4_M84_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c111 x_PM_BUF_X32%4_193 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c112 N_4_M35_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c113 N_4_M83_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c114 x_PM_BUF_X32%4_183 VSS 1.18385e-17
C_x_PM_BUF_X32%4_c115 N_4_M34_g VSS 3.11751e-17
C_x_PM_BUF_X32%4_c116 N_4_M82_g VSS 3.17203e-17
C_x_PM_BUF_X32%4_c117 N_4_M33_g VSS 3.0497e-17
C_x_PM_BUF_X32%4_c118 N_4_M81_g VSS 3.17743e-17
C_x_PM_BUF_X32%4_c119 x_PM_BUF_X32%4_165 VSS 1.17662e-17
C_x_PM_BUF_X32%4_c120 N_4_M32_g VSS 3.14605e-17
C_x_PM_BUF_X32%4_c121 N_4_M80_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c122 x_PM_BUF_X32%4_155 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c123 N_4_M31_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c124 N_4_M79_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c125 x_PM_BUF_X32%4_145 VSS 1.20629e-17
C_x_PM_BUF_X32%4_c126 N_4_M30_g VSS 3.14605e-17
C_x_PM_BUF_X32%4_c127 N_4_M78_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c128 x_PM_BUF_X32%4_135 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c129 N_4_M29_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c130 N_4_M77_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c131 x_PM_BUF_X32%4_125 VSS 1.18385e-17
C_x_PM_BUF_X32%4_c132 N_4_M28_g VSS 3.11751e-17
C_x_PM_BUF_X32%4_c133 N_4_M76_g VSS 3.17203e-17
C_x_PM_BUF_X32%4_c134 N_4_M27_g VSS 3.0497e-17
C_x_PM_BUF_X32%4_c135 N_4_M75_g VSS 3.17743e-17
C_x_PM_BUF_X32%4_c136 x_PM_BUF_X32%4_107 VSS 1.17662e-17
C_x_PM_BUF_X32%4_c137 N_4_M26_g VSS 3.14605e-17
C_x_PM_BUF_X32%4_c138 N_4_M74_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c139 x_PM_BUF_X32%4_97 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c140 N_4_M25_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c141 N_4_M73_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c142 x_PM_BUF_X32%4_87 VSS 1.20629e-17
C_x_PM_BUF_X32%4_c143 N_4_M24_g VSS 3.14605e-17
C_x_PM_BUF_X32%4_c144 N_4_M72_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c145 x_PM_BUF_X32%4_77 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c146 N_4_M23_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c147 N_4_M71_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c148 x_PM_BUF_X32%4_67 VSS 1.18385e-17
C_x_PM_BUF_X32%4_c149 N_4_M22_g VSS 3.11751e-17
C_x_PM_BUF_X32%4_c150 N_4_M70_g VSS 3.17203e-17
C_x_PM_BUF_X32%4_c151 N_4_M21_g VSS 3.0497e-17
C_x_PM_BUF_X32%4_c152 N_4_M69_g VSS 3.17743e-17
C_x_PM_BUF_X32%4_c153 x_PM_BUF_X32%4_49 VSS 1.17662e-17
C_x_PM_BUF_X32%4_c154 N_4_M20_g VSS 3.14605e-17
C_x_PM_BUF_X32%4_c155 N_4_M68_g VSS 3.16243e-17
C_x_PM_BUF_X32%4_c156 x_PM_BUF_X32%4_39 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c157 N_4_M19_g VSS 3.11676e-17
C_x_PM_BUF_X32%4_c158 N_4_M67_g VSS 3.18916e-17
C_x_PM_BUF_X32%4_c159 x_PM_BUF_X32%4_29 VSS 1.20501e-17
C_x_PM_BUF_X32%4_c160 N_4_M18_g VSS 3.15061e-17
C_x_PM_BUF_X32%4_c161 N_4_M66_g VSS 3.16411e-17
C_x_PM_BUF_X32%4_c162 x_PM_BUF_X32%4_19 VSS 6.7474e-18
C_x_PM_BUF_X32%4_c163 N_4_M17_g VSS 3.22676e-17
C_x_PM_BUF_X32%4_c164 N_4_M65_g VSS 3.22339e-17
C_x_PM_BUF_X32%4_c165 x_PM_BUF_X32%4_9 VSS 1.35839e-17
C_x_PM_BUF_X32%4_c166 N_4_M16_g VSS 5.02397e-17
C_x_PM_BUF_X32%4_c167 N_4_M64_g VSS 3.84228e-17
R_x_PM_BUF_X32%4_r168 x_PM_BUF_X32%4_473 x_PM_BUF_X32%4_475 0.656916
R_x_PM_BUF_X32%4_r169 x_PM_BUF_X32%4_473 x_PM_BUF_X32%4_492 25.0012
R_x_PM_BUF_X32%4_r170 x_PM_BUF_X32%4_472 x_PM_BUF_X32%4_487 0.266978
R_x_PM_BUF_X32%4_r171 x_PM_BUF_X32%4_471 x_PM_BUF_X32%4_475 0.241334
R_x_PM_BUF_X32%4_r172 x_PM_BUF_X32%4_471 x_PM_BUF_X32%4_472 5.45571
R_x_PM_BUF_X32%4_r173 x_PM_BUF_X32%4_470 x_PM_BUF_X32%4_487 0.0272847
R_x_PM_BUF_X32%4_r174 x_PM_BUF_X32%4_468 x_PM_BUF_X32%4_470 0.656916
R_x_PM_BUF_X32%4_r175 x_PM_BUF_X32%4_468 x_PM_BUF_X32%4_469 25.0012
R_x_PM_BUF_X32%4_r176 x_PM_BUF_X32%4_467 x_PM_BUF_X32%4_486 0.266978
R_x_PM_BUF_X32%4_r177 x_PM_BUF_X32%4_466 x_PM_BUF_X32%4_487 0.266978
R_x_PM_BUF_X32%4_r178 x_PM_BUF_X32%4_466 x_PM_BUF_X32%4_467 5.45571
R_x_PM_BUF_X32%4_r179 x_PM_BUF_X32%4_465 x_PM_BUF_X32%4_486 0.0272847
R_x_PM_BUF_X32%4_r180 x_PM_BUF_X32%4_463 x_PM_BUF_X32%4_465 0.656916
R_x_PM_BUF_X32%4_r181 x_PM_BUF_X32%4_463 x_PM_BUF_X32%4_464 25.0012
R_x_PM_BUF_X32%4_r182 x_PM_BUF_X32%4_462 x_PM_BUF_X32%4_485 0.266978
R_x_PM_BUF_X32%4_r183 x_PM_BUF_X32%4_461 x_PM_BUF_X32%4_486 0.266978
R_x_PM_BUF_X32%4_r184 x_PM_BUF_X32%4_461 x_PM_BUF_X32%4_462 5.45571
R_x_PM_BUF_X32%4_r185 x_PM_BUF_X32%4_460 x_PM_BUF_X32%4_485 0.0272847
R_x_PM_BUF_X32%4_r186 x_PM_BUF_X32%4_458 x_PM_BUF_X32%4_460 0.656916
R_x_PM_BUF_X32%4_r187 x_PM_BUF_X32%4_458 x_PM_BUF_X32%4_459 25.0012
R_x_PM_BUF_X32%4_r188 x_PM_BUF_X32%4_457 x_PM_BUF_X32%4_484 0.266978
R_x_PM_BUF_X32%4_r189 x_PM_BUF_X32%4_456 x_PM_BUF_X32%4_485 0.266978
R_x_PM_BUF_X32%4_r190 x_PM_BUF_X32%4_456 x_PM_BUF_X32%4_457 5.45571
R_x_PM_BUF_X32%4_r191 x_PM_BUF_X32%4_455 x_PM_BUF_X32%4_484 0.0272847
R_x_PM_BUF_X32%4_r192 x_PM_BUF_X32%4_453 x_PM_BUF_X32%4_455 0.656916
R_x_PM_BUF_X32%4_r193 x_PM_BUF_X32%4_453 x_PM_BUF_X32%4_454 25.0012
R_x_PM_BUF_X32%4_r194 x_PM_BUF_X32%4_451 x_PM_BUF_X32%4_484 0.266978
R_x_PM_BUF_X32%4_r195 x_PM_BUF_X32%4_451 x_PM_BUF_X32%4_452 5.15714
R_x_PM_BUF_X32%4_r196 x_PM_BUF_X32%4_448 x_PM_BUF_X32%4_450 25.0012
R_x_PM_BUF_X32%4_r197 x_PM_BUF_X32%4_447 x_PM_BUF_X32%4_452 0.212317
R_x_PM_BUF_X32%4_r198 x_PM_BUF_X32%4_447 x_PM_BUF_X32%4_448 1.39786
R_x_PM_BUF_X32%4_r199 x_PM_BUF_X32%4_446 x_PM_BUF_X32%4_448 0.529286
R_x_PM_BUF_X32%4_r200 x_PM_BUF_X32%4_445 x_PM_BUF_X32%4_483 0.0950001
R_x_PM_BUF_X32%4_r201 x_PM_BUF_X32%4_444 x_PM_BUF_X32%4_446 0.21666
R_x_PM_BUF_X32%4_r202 x_PM_BUF_X32%4_444 x_PM_BUF_X32%4_445 0.865556
R_x_PM_BUF_X32%4_r203 x_PM_BUF_X32%4_440 x_PM_BUF_X32%4_483 0.0950001
R_x_PM_BUF_X32%4_r204 x_PM_BUF_X32%4_440 N_4_M62_d 0.257857
R_x_PM_BUF_X32%4_r205 x_PM_BUF_X32%4_436 x_PM_BUF_X32%4_483 0.0950001
R_x_PM_BUF_X32%4_r206 x_PM_BUF_X32%4_436 N_4_M14_d 1.64214
R_x_PM_BUF_X32%4_r207 x_PM_BUF_X32%4_435 x_PM_BUF_X32%4_482 0.0950001
R_x_PM_BUF_X32%4_r208 x_PM_BUF_X32%4_434 x_PM_BUF_X32%4_483 0.0950001
R_x_PM_BUF_X32%4_r209 x_PM_BUF_X32%4_434 x_PM_BUF_X32%4_435 1.30889
R_x_PM_BUF_X32%4_r210 x_PM_BUF_X32%4_430 x_PM_BUF_X32%4_482 0.0950001
R_x_PM_BUF_X32%4_r211 x_PM_BUF_X32%4_430 N_4_M12_d 1.64214
R_x_PM_BUF_X32%4_r212 x_PM_BUF_X32%4_426 x_PM_BUF_X32%4_482 0.0950001
R_x_PM_BUF_X32%4_r213 x_PM_BUF_X32%4_426 N_4_M60_d 0.257857
R_x_PM_BUF_X32%4_r214 x_PM_BUF_X32%4_425 x_PM_BUF_X32%4_481 0.0950001
R_x_PM_BUF_X32%4_r215 x_PM_BUF_X32%4_424 x_PM_BUF_X32%4_482 0.0950001
R_x_PM_BUF_X32%4_r216 x_PM_BUF_X32%4_424 x_PM_BUF_X32%4_425 1.28778
R_x_PM_BUF_X32%4_r217 x_PM_BUF_X32%4_420 x_PM_BUF_X32%4_481 0.0950001
R_x_PM_BUF_X32%4_r218 x_PM_BUF_X32%4_420 N_4_M10_d 1.64214
R_x_PM_BUF_X32%4_r219 x_PM_BUF_X32%4_416 x_PM_BUF_X32%4_481 0.0950001
R_x_PM_BUF_X32%4_r220 x_PM_BUF_X32%4_416 N_4_M58_d 0.257857
R_x_PM_BUF_X32%4_r221 x_PM_BUF_X32%4_415 x_PM_BUF_X32%4_480 0.0950001
R_x_PM_BUF_X32%4_r222 x_PM_BUF_X32%4_414 x_PM_BUF_X32%4_481 0.0950001
R_x_PM_BUF_X32%4_r223 x_PM_BUF_X32%4_414 x_PM_BUF_X32%4_415 1.30889
R_x_PM_BUF_X32%4_r224 x_PM_BUF_X32%4_410 x_PM_BUF_X32%4_480 0.0950001
R_x_PM_BUF_X32%4_r225 x_PM_BUF_X32%4_410 N_4_M56_d 0.257857
R_x_PM_BUF_X32%4_r226 x_PM_BUF_X32%4_406 x_PM_BUF_X32%4_480 0.0950001
R_x_PM_BUF_X32%4_r227 x_PM_BUF_X32%4_406 N_4_M8_d 1.64214
R_x_PM_BUF_X32%4_r228 x_PM_BUF_X32%4_405 x_PM_BUF_X32%4_479 0.0950001
R_x_PM_BUF_X32%4_r229 x_PM_BUF_X32%4_404 x_PM_BUF_X32%4_480 0.0950001
R_x_PM_BUF_X32%4_r230 x_PM_BUF_X32%4_404 x_PM_BUF_X32%4_405 1.30889
R_x_PM_BUF_X32%4_r231 x_PM_BUF_X32%4_400 x_PM_BUF_X32%4_479 0.0950001
R_x_PM_BUF_X32%4_r232 x_PM_BUF_X32%4_400 N_4_M6_d 1.64214
R_x_PM_BUF_X32%4_r233 x_PM_BUF_X32%4_396 x_PM_BUF_X32%4_479 0.0950001
R_x_PM_BUF_X32%4_r234 x_PM_BUF_X32%4_396 N_4_M54_d 0.257857
R_x_PM_BUF_X32%4_r235 x_PM_BUF_X32%4_395 x_PM_BUF_X32%4_478 0.0950001
R_x_PM_BUF_X32%4_r236 x_PM_BUF_X32%4_394 x_PM_BUF_X32%4_479 0.0950001
R_x_PM_BUF_X32%4_r237 x_PM_BUF_X32%4_394 x_PM_BUF_X32%4_395 1.30889
R_x_PM_BUF_X32%4_r238 x_PM_BUF_X32%4_390 x_PM_BUF_X32%4_478 0.0950001
R_x_PM_BUF_X32%4_r239 x_PM_BUF_X32%4_390 N_4_M4_d 1.64214
R_x_PM_BUF_X32%4_r240 x_PM_BUF_X32%4_386 x_PM_BUF_X32%4_478 0.0950001
R_x_PM_BUF_X32%4_r241 x_PM_BUF_X32%4_386 N_4_M52_d 0.257857
R_x_PM_BUF_X32%4_r242 x_PM_BUF_X32%4_385 x_PM_BUF_X32%4_477 0.0950001
R_x_PM_BUF_X32%4_r243 x_PM_BUF_X32%4_384 x_PM_BUF_X32%4_478 0.0950001
R_x_PM_BUF_X32%4_r244 x_PM_BUF_X32%4_384 x_PM_BUF_X32%4_385 1.26667
R_x_PM_BUF_X32%4_r245 x_PM_BUF_X32%4_380 x_PM_BUF_X32%4_477 0.0950001
R_x_PM_BUF_X32%4_r246 x_PM_BUF_X32%4_380 N_4_M2_d 1.64214
R_x_PM_BUF_X32%4_r247 x_PM_BUF_X32%4_376 x_PM_BUF_X32%4_477 0.0950001
R_x_PM_BUF_X32%4_r248 x_PM_BUF_X32%4_376 N_4_M50_d 0.257857
R_x_PM_BUF_X32%4_r249 x_PM_BUF_X32%4_375 x_PM_BUF_X32%4_476 0.0141807
R_x_PM_BUF_X32%4_r250 x_PM_BUF_X32%4_374 x_PM_BUF_X32%4_477 0.0950001
R_x_PM_BUF_X32%4_r251 x_PM_BUF_X32%4_374 x_PM_BUF_X32%4_375 1.26667
R_x_PM_BUF_X32%4_r252 x_PM_BUF_X32%4_370 x_PM_BUF_X32%4_476 0.197273
R_x_PM_BUF_X32%4_r253 x_PM_BUF_X32%4_370 N_4_M0_d 1.64214
R_x_PM_BUF_X32%4_r254 x_PM_BUF_X32%4_366 x_PM_BUF_X32%4_476 0.197273
R_x_PM_BUF_X32%4_r255 x_PM_BUF_X32%4_366 N_4_M48_d 0.257857
R_x_PM_BUF_X32%4_r256 x_PM_BUF_X32%4_347 x_PM_BUF_X32%4_492 10.14
R_x_PM_BUF_X32%4_r257 x_PM_BUF_X32%4_347 x_PM_BUF_X32%4_348 1.95
R_x_PM_BUF_X32%4_r258 x_PM_BUF_X32%4_345 x_PM_BUF_X32%4_492 4.42
R_x_PM_BUF_X32%4_r259 x_PM_BUF_X32%4_345 x_PM_BUF_X32%4_346 1.95
R_x_PM_BUF_X32%4_r260 x_PM_BUF_X32%4_339 x_PM_BUF_X32%4_469 10.14
R_x_PM_BUF_X32%4_r261 x_PM_BUF_X32%4_339 x_PM_BUF_X32%4_340 1.95
R_x_PM_BUF_X32%4_r262 x_PM_BUF_X32%4_337 x_PM_BUF_X32%4_469 4.42
R_x_PM_BUF_X32%4_r263 x_PM_BUF_X32%4_337 x_PM_BUF_X32%4_338 1.95
R_x_PM_BUF_X32%4_r264 x_PM_BUF_X32%4_331 x_PM_BUF_X32%4_464 10.14
R_x_PM_BUF_X32%4_r265 x_PM_BUF_X32%4_331 x_PM_BUF_X32%4_332 1.95
R_x_PM_BUF_X32%4_r266 x_PM_BUF_X32%4_329 x_PM_BUF_X32%4_464 4.42
R_x_PM_BUF_X32%4_r267 x_PM_BUF_X32%4_329 x_PM_BUF_X32%4_330 1.95
R_x_PM_BUF_X32%4_r268 x_PM_BUF_X32%4_323 x_PM_BUF_X32%4_459 10.14
R_x_PM_BUF_X32%4_r269 x_PM_BUF_X32%4_323 x_PM_BUF_X32%4_324 1.95
R_x_PM_BUF_X32%4_r270 x_PM_BUF_X32%4_321 x_PM_BUF_X32%4_459 4.42
R_x_PM_BUF_X32%4_r271 x_PM_BUF_X32%4_321 x_PM_BUF_X32%4_322 1.95
R_x_PM_BUF_X32%4_r272 x_PM_BUF_X32%4_315 x_PM_BUF_X32%4_454 10.14
R_x_PM_BUF_X32%4_r273 x_PM_BUF_X32%4_315 x_PM_BUF_X32%4_316 1.95
R_x_PM_BUF_X32%4_r274 x_PM_BUF_X32%4_313 x_PM_BUF_X32%4_454 4.42
R_x_PM_BUF_X32%4_r275 x_PM_BUF_X32%4_313 x_PM_BUF_X32%4_314 1.95
R_x_PM_BUF_X32%4_r276 x_PM_BUF_X32%4_305 x_PM_BUF_X32%4_349 4.56151
R_x_PM_BUF_X32%4_r277 x_PM_BUF_X32%4_305 N_4_M47_g 56.94
R_x_PM_BUF_X32%4_r278 x_PM_BUF_X32%4_301 x_PM_BUF_X32%4_349 4.56151
R_x_PM_BUF_X32%4_r279 x_PM_BUF_X32%4_301 N_4_M95_g 40.17
R_x_PM_BUF_X32%4_r280 x_PM_BUF_X32%4_300 x_PM_BUF_X32%4_348 1.95
R_x_PM_BUF_X32%4_r281 x_PM_BUF_X32%4_299 x_PM_BUF_X32%4_349 0.043368
R_x_PM_BUF_X32%4_r282 x_PM_BUF_X32%4_299 x_PM_BUF_X32%4_300 14.56
R_x_PM_BUF_X32%4_r283 x_PM_BUF_X32%4_295 x_PM_BUF_X32%4_348 1.95
R_x_PM_BUF_X32%4_r284 x_PM_BUF_X32%4_295 N_4_M46_g 56.94
R_x_PM_BUF_X32%4_r285 x_PM_BUF_X32%4_291 x_PM_BUF_X32%4_348 1.95
R_x_PM_BUF_X32%4_r286 x_PM_BUF_X32%4_291 N_4_M94_g 40.17
R_x_PM_BUF_X32%4_r287 x_PM_BUF_X32%4_287 x_PM_BUF_X32%4_346 1.95
R_x_PM_BUF_X32%4_r288 x_PM_BUF_X32%4_287 N_4_M45_g 56.94
R_x_PM_BUF_X32%4_r289 x_PM_BUF_X32%4_283 x_PM_BUF_X32%4_346 1.95
R_x_PM_BUF_X32%4_r290 x_PM_BUF_X32%4_283 N_4_M93_g 40.17
R_x_PM_BUF_X32%4_r291 x_PM_BUF_X32%4_282 x_PM_BUF_X32%4_344 1.95
R_x_PM_BUF_X32%4_r292 x_PM_BUF_X32%4_281 x_PM_BUF_X32%4_346 1.95
R_x_PM_BUF_X32%4_r293 x_PM_BUF_X32%4_281 x_PM_BUF_X32%4_282 14.56
R_x_PM_BUF_X32%4_r294 x_PM_BUF_X32%4_277 x_PM_BUF_X32%4_344 1.95
R_x_PM_BUF_X32%4_r295 x_PM_BUF_X32%4_277 N_4_M44_g 56.94
R_x_PM_BUF_X32%4_r296 x_PM_BUF_X32%4_273 x_PM_BUF_X32%4_344 1.95
R_x_PM_BUF_X32%4_r297 x_PM_BUF_X32%4_273 N_4_M92_g 40.17
R_x_PM_BUF_X32%4_r298 x_PM_BUF_X32%4_272 x_PM_BUF_X32%4_343 1.95
R_x_PM_BUF_X32%4_r299 x_PM_BUF_X32%4_271 x_PM_BUF_X32%4_344 1.95
R_x_PM_BUF_X32%4_r300 x_PM_BUF_X32%4_271 x_PM_BUF_X32%4_272 14.56
R_x_PM_BUF_X32%4_r301 x_PM_BUF_X32%4_267 x_PM_BUF_X32%4_343 1.95
R_x_PM_BUF_X32%4_r302 x_PM_BUF_X32%4_267 N_4_M43_g 56.94
R_x_PM_BUF_X32%4_r303 x_PM_BUF_X32%4_263 x_PM_BUF_X32%4_343 1.95
R_x_PM_BUF_X32%4_r304 x_PM_BUF_X32%4_263 N_4_M91_g 40.17
R_x_PM_BUF_X32%4_r305 x_PM_BUF_X32%4_262 x_PM_BUF_X32%4_342 1.95
R_x_PM_BUF_X32%4_r306 x_PM_BUF_X32%4_261 x_PM_BUF_X32%4_343 1.95
R_x_PM_BUF_X32%4_r307 x_PM_BUF_X32%4_261 x_PM_BUF_X32%4_262 14.56
R_x_PM_BUF_X32%4_r308 x_PM_BUF_X32%4_257 x_PM_BUF_X32%4_342 1.95
R_x_PM_BUF_X32%4_r309 x_PM_BUF_X32%4_257 N_4_M42_g 56.94
R_x_PM_BUF_X32%4_r310 x_PM_BUF_X32%4_253 x_PM_BUF_X32%4_342 1.95
R_x_PM_BUF_X32%4_r311 x_PM_BUF_X32%4_253 N_4_M90_g 40.17
R_x_PM_BUF_X32%4_r312 x_PM_BUF_X32%4_252 x_PM_BUF_X32%4_341 1.95
R_x_PM_BUF_X32%4_r313 x_PM_BUF_X32%4_251 x_PM_BUF_X32%4_342 1.95
R_x_PM_BUF_X32%4_r314 x_PM_BUF_X32%4_251 x_PM_BUF_X32%4_252 14.56
R_x_PM_BUF_X32%4_r315 x_PM_BUF_X32%4_247 x_PM_BUF_X32%4_341 1.95
R_x_PM_BUF_X32%4_r316 x_PM_BUF_X32%4_247 N_4_M41_g 56.94
R_x_PM_BUF_X32%4_r317 x_PM_BUF_X32%4_243 x_PM_BUF_X32%4_341 1.95
R_x_PM_BUF_X32%4_r318 x_PM_BUF_X32%4_243 N_4_M89_g 40.17
R_x_PM_BUF_X32%4_r319 x_PM_BUF_X32%4_242 x_PM_BUF_X32%4_340 1.95
R_x_PM_BUF_X32%4_r320 x_PM_BUF_X32%4_241 x_PM_BUF_X32%4_341 1.95
R_x_PM_BUF_X32%4_r321 x_PM_BUF_X32%4_241 x_PM_BUF_X32%4_242 14.56
R_x_PM_BUF_X32%4_r322 x_PM_BUF_X32%4_237 x_PM_BUF_X32%4_340 1.95
R_x_PM_BUF_X32%4_r323 x_PM_BUF_X32%4_237 N_4_M40_g 56.94
R_x_PM_BUF_X32%4_r324 x_PM_BUF_X32%4_233 x_PM_BUF_X32%4_340 1.95
R_x_PM_BUF_X32%4_r325 x_PM_BUF_X32%4_233 N_4_M88_g 40.17
R_x_PM_BUF_X32%4_r326 x_PM_BUF_X32%4_229 x_PM_BUF_X32%4_338 1.95
R_x_PM_BUF_X32%4_r327 x_PM_BUF_X32%4_229 N_4_M39_g 56.94
R_x_PM_BUF_X32%4_r328 x_PM_BUF_X32%4_225 x_PM_BUF_X32%4_338 1.95
R_x_PM_BUF_X32%4_r329 x_PM_BUF_X32%4_225 N_4_M87_g 40.17
R_x_PM_BUF_X32%4_r330 x_PM_BUF_X32%4_224 x_PM_BUF_X32%4_336 1.95
R_x_PM_BUF_X32%4_r331 x_PM_BUF_X32%4_223 x_PM_BUF_X32%4_338 1.95
R_x_PM_BUF_X32%4_r332 x_PM_BUF_X32%4_223 x_PM_BUF_X32%4_224 14.56
R_x_PM_BUF_X32%4_r333 x_PM_BUF_X32%4_219 x_PM_BUF_X32%4_336 1.95
R_x_PM_BUF_X32%4_r334 x_PM_BUF_X32%4_219 N_4_M38_g 56.94
R_x_PM_BUF_X32%4_r335 x_PM_BUF_X32%4_215 x_PM_BUF_X32%4_336 1.95
R_x_PM_BUF_X32%4_r336 x_PM_BUF_X32%4_215 N_4_M86_g 40.17
R_x_PM_BUF_X32%4_r337 x_PM_BUF_X32%4_214 x_PM_BUF_X32%4_335 1.95
R_x_PM_BUF_X32%4_r338 x_PM_BUF_X32%4_213 x_PM_BUF_X32%4_336 1.95
R_x_PM_BUF_X32%4_r339 x_PM_BUF_X32%4_213 x_PM_BUF_X32%4_214 14.56
R_x_PM_BUF_X32%4_r340 x_PM_BUF_X32%4_209 x_PM_BUF_X32%4_335 1.95
R_x_PM_BUF_X32%4_r341 x_PM_BUF_X32%4_209 N_4_M37_g 56.94
R_x_PM_BUF_X32%4_r342 x_PM_BUF_X32%4_205 x_PM_BUF_X32%4_335 1.95
R_x_PM_BUF_X32%4_r343 x_PM_BUF_X32%4_205 N_4_M85_g 40.17
R_x_PM_BUF_X32%4_r344 x_PM_BUF_X32%4_204 x_PM_BUF_X32%4_334 1.95
R_x_PM_BUF_X32%4_r345 x_PM_BUF_X32%4_203 x_PM_BUF_X32%4_335 1.95
R_x_PM_BUF_X32%4_r346 x_PM_BUF_X32%4_203 x_PM_BUF_X32%4_204 14.56
R_x_PM_BUF_X32%4_r347 x_PM_BUF_X32%4_199 x_PM_BUF_X32%4_334 1.95
R_x_PM_BUF_X32%4_r348 x_PM_BUF_X32%4_199 N_4_M36_g 56.94
R_x_PM_BUF_X32%4_r349 x_PM_BUF_X32%4_195 x_PM_BUF_X32%4_334 1.95
R_x_PM_BUF_X32%4_r350 x_PM_BUF_X32%4_195 N_4_M84_g 40.17
R_x_PM_BUF_X32%4_r351 x_PM_BUF_X32%4_194 x_PM_BUF_X32%4_333 1.95
R_x_PM_BUF_X32%4_r352 x_PM_BUF_X32%4_193 x_PM_BUF_X32%4_334 1.95
R_x_PM_BUF_X32%4_r353 x_PM_BUF_X32%4_193 x_PM_BUF_X32%4_194 14.56
R_x_PM_BUF_X32%4_r354 x_PM_BUF_X32%4_189 x_PM_BUF_X32%4_333 1.95
R_x_PM_BUF_X32%4_r355 x_PM_BUF_X32%4_189 N_4_M35_g 56.94
R_x_PM_BUF_X32%4_r356 x_PM_BUF_X32%4_185 x_PM_BUF_X32%4_333 1.95
R_x_PM_BUF_X32%4_r357 x_PM_BUF_X32%4_185 N_4_M83_g 40.17
R_x_PM_BUF_X32%4_r358 x_PM_BUF_X32%4_184 x_PM_BUF_X32%4_332 1.95
R_x_PM_BUF_X32%4_r359 x_PM_BUF_X32%4_183 x_PM_BUF_X32%4_333 1.95
R_x_PM_BUF_X32%4_r360 x_PM_BUF_X32%4_183 x_PM_BUF_X32%4_184 14.56
R_x_PM_BUF_X32%4_r361 x_PM_BUF_X32%4_179 x_PM_BUF_X32%4_332 1.95
R_x_PM_BUF_X32%4_r362 x_PM_BUF_X32%4_179 N_4_M34_g 56.94
R_x_PM_BUF_X32%4_r363 x_PM_BUF_X32%4_175 x_PM_BUF_X32%4_332 1.95
R_x_PM_BUF_X32%4_r364 x_PM_BUF_X32%4_175 N_4_M82_g 40.17
R_x_PM_BUF_X32%4_r365 x_PM_BUF_X32%4_171 x_PM_BUF_X32%4_330 1.95
R_x_PM_BUF_X32%4_r366 x_PM_BUF_X32%4_171 N_4_M33_g 56.94
R_x_PM_BUF_X32%4_r367 x_PM_BUF_X32%4_167 x_PM_BUF_X32%4_330 1.95
R_x_PM_BUF_X32%4_r368 x_PM_BUF_X32%4_167 N_4_M81_g 40.17
R_x_PM_BUF_X32%4_r369 x_PM_BUF_X32%4_166 x_PM_BUF_X32%4_328 1.95
R_x_PM_BUF_X32%4_r370 x_PM_BUF_X32%4_165 x_PM_BUF_X32%4_330 1.95
R_x_PM_BUF_X32%4_r371 x_PM_BUF_X32%4_165 x_PM_BUF_X32%4_166 14.56
R_x_PM_BUF_X32%4_r372 x_PM_BUF_X32%4_161 x_PM_BUF_X32%4_328 1.95
R_x_PM_BUF_X32%4_r373 x_PM_BUF_X32%4_161 N_4_M32_g 56.94
R_x_PM_BUF_X32%4_r374 x_PM_BUF_X32%4_157 x_PM_BUF_X32%4_328 1.95
R_x_PM_BUF_X32%4_r375 x_PM_BUF_X32%4_157 N_4_M80_g 40.17
R_x_PM_BUF_X32%4_r376 x_PM_BUF_X32%4_156 x_PM_BUF_X32%4_327 1.95
R_x_PM_BUF_X32%4_r377 x_PM_BUF_X32%4_155 x_PM_BUF_X32%4_328 1.95
R_x_PM_BUF_X32%4_r378 x_PM_BUF_X32%4_155 x_PM_BUF_X32%4_156 14.56
R_x_PM_BUF_X32%4_r379 x_PM_BUF_X32%4_151 x_PM_BUF_X32%4_327 1.95
R_x_PM_BUF_X32%4_r380 x_PM_BUF_X32%4_151 N_4_M31_g 56.94
R_x_PM_BUF_X32%4_r381 x_PM_BUF_X32%4_147 x_PM_BUF_X32%4_327 1.95
R_x_PM_BUF_X32%4_r382 x_PM_BUF_X32%4_147 N_4_M79_g 40.17
R_x_PM_BUF_X32%4_r383 x_PM_BUF_X32%4_146 x_PM_BUF_X32%4_326 1.95
R_x_PM_BUF_X32%4_r384 x_PM_BUF_X32%4_145 x_PM_BUF_X32%4_327 1.95
R_x_PM_BUF_X32%4_r385 x_PM_BUF_X32%4_145 x_PM_BUF_X32%4_146 14.56
R_x_PM_BUF_X32%4_r386 x_PM_BUF_X32%4_141 x_PM_BUF_X32%4_326 1.95
R_x_PM_BUF_X32%4_r387 x_PM_BUF_X32%4_141 N_4_M30_g 56.94
R_x_PM_BUF_X32%4_r388 x_PM_BUF_X32%4_137 x_PM_BUF_X32%4_326 1.95
R_x_PM_BUF_X32%4_r389 x_PM_BUF_X32%4_137 N_4_M78_g 40.17
R_x_PM_BUF_X32%4_r390 x_PM_BUF_X32%4_136 x_PM_BUF_X32%4_325 1.95
R_x_PM_BUF_X32%4_r391 x_PM_BUF_X32%4_135 x_PM_BUF_X32%4_326 1.95
R_x_PM_BUF_X32%4_r392 x_PM_BUF_X32%4_135 x_PM_BUF_X32%4_136 14.56
R_x_PM_BUF_X32%4_r393 x_PM_BUF_X32%4_131 x_PM_BUF_X32%4_325 1.95
R_x_PM_BUF_X32%4_r394 x_PM_BUF_X32%4_131 N_4_M29_g 56.94
R_x_PM_BUF_X32%4_r395 x_PM_BUF_X32%4_127 x_PM_BUF_X32%4_325 1.95
R_x_PM_BUF_X32%4_r396 x_PM_BUF_X32%4_127 N_4_M77_g 40.17
R_x_PM_BUF_X32%4_r397 x_PM_BUF_X32%4_126 x_PM_BUF_X32%4_324 1.95
R_x_PM_BUF_X32%4_r398 x_PM_BUF_X32%4_125 x_PM_BUF_X32%4_325 1.95
R_x_PM_BUF_X32%4_r399 x_PM_BUF_X32%4_125 x_PM_BUF_X32%4_126 14.56
R_x_PM_BUF_X32%4_r400 x_PM_BUF_X32%4_121 x_PM_BUF_X32%4_324 1.95
R_x_PM_BUF_X32%4_r401 x_PM_BUF_X32%4_121 N_4_M28_g 56.94
R_x_PM_BUF_X32%4_r402 x_PM_BUF_X32%4_117 x_PM_BUF_X32%4_324 1.95
R_x_PM_BUF_X32%4_r403 x_PM_BUF_X32%4_117 N_4_M76_g 40.17
R_x_PM_BUF_X32%4_r404 x_PM_BUF_X32%4_113 x_PM_BUF_X32%4_322 1.95
R_x_PM_BUF_X32%4_r405 x_PM_BUF_X32%4_113 N_4_M27_g 56.94
R_x_PM_BUF_X32%4_r406 x_PM_BUF_X32%4_109 x_PM_BUF_X32%4_322 1.95
R_x_PM_BUF_X32%4_r407 x_PM_BUF_X32%4_109 N_4_M75_g 40.17
R_x_PM_BUF_X32%4_r408 x_PM_BUF_X32%4_108 x_PM_BUF_X32%4_320 1.95
R_x_PM_BUF_X32%4_r409 x_PM_BUF_X32%4_107 x_PM_BUF_X32%4_322 1.95
R_x_PM_BUF_X32%4_r410 x_PM_BUF_X32%4_107 x_PM_BUF_X32%4_108 14.56
R_x_PM_BUF_X32%4_r411 x_PM_BUF_X32%4_103 x_PM_BUF_X32%4_320 1.95
R_x_PM_BUF_X32%4_r412 x_PM_BUF_X32%4_103 N_4_M26_g 56.94
R_x_PM_BUF_X32%4_r413 x_PM_BUF_X32%4_99 x_PM_BUF_X32%4_320 1.95
R_x_PM_BUF_X32%4_r414 x_PM_BUF_X32%4_99 N_4_M74_g 40.17
R_x_PM_BUF_X32%4_r415 x_PM_BUF_X32%4_98 x_PM_BUF_X32%4_319 1.95
R_x_PM_BUF_X32%4_r416 x_PM_BUF_X32%4_97 x_PM_BUF_X32%4_320 1.95
R_x_PM_BUF_X32%4_r417 x_PM_BUF_X32%4_97 x_PM_BUF_X32%4_98 14.56
R_x_PM_BUF_X32%4_r418 x_PM_BUF_X32%4_93 x_PM_BUF_X32%4_319 1.95
R_x_PM_BUF_X32%4_r419 x_PM_BUF_X32%4_93 N_4_M25_g 56.94
R_x_PM_BUF_X32%4_r420 x_PM_BUF_X32%4_89 x_PM_BUF_X32%4_319 1.95
R_x_PM_BUF_X32%4_r421 x_PM_BUF_X32%4_89 N_4_M73_g 40.17
R_x_PM_BUF_X32%4_r422 x_PM_BUF_X32%4_88 x_PM_BUF_X32%4_318 1.95
R_x_PM_BUF_X32%4_r423 x_PM_BUF_X32%4_87 x_PM_BUF_X32%4_319 1.95
R_x_PM_BUF_X32%4_r424 x_PM_BUF_X32%4_87 x_PM_BUF_X32%4_88 14.56
R_x_PM_BUF_X32%4_r425 x_PM_BUF_X32%4_83 x_PM_BUF_X32%4_318 1.95
R_x_PM_BUF_X32%4_r426 x_PM_BUF_X32%4_83 N_4_M24_g 56.94
R_x_PM_BUF_X32%4_r427 x_PM_BUF_X32%4_79 x_PM_BUF_X32%4_318 1.95
R_x_PM_BUF_X32%4_r428 x_PM_BUF_X32%4_79 N_4_M72_g 40.17
R_x_PM_BUF_X32%4_r429 x_PM_BUF_X32%4_78 x_PM_BUF_X32%4_317 1.95
R_x_PM_BUF_X32%4_r430 x_PM_BUF_X32%4_77 x_PM_BUF_X32%4_318 1.95
R_x_PM_BUF_X32%4_r431 x_PM_BUF_X32%4_77 x_PM_BUF_X32%4_78 14.56
R_x_PM_BUF_X32%4_r432 x_PM_BUF_X32%4_73 x_PM_BUF_X32%4_317 1.95
R_x_PM_BUF_X32%4_r433 x_PM_BUF_X32%4_73 N_4_M23_g 56.94
R_x_PM_BUF_X32%4_r434 x_PM_BUF_X32%4_69 x_PM_BUF_X32%4_317 1.95
R_x_PM_BUF_X32%4_r435 x_PM_BUF_X32%4_69 N_4_M71_g 40.17
R_x_PM_BUF_X32%4_r436 x_PM_BUF_X32%4_68 x_PM_BUF_X32%4_316 1.95
R_x_PM_BUF_X32%4_r437 x_PM_BUF_X32%4_67 x_PM_BUF_X32%4_317 1.95
R_x_PM_BUF_X32%4_r438 x_PM_BUF_X32%4_67 x_PM_BUF_X32%4_68 14.56
R_x_PM_BUF_X32%4_r439 x_PM_BUF_X32%4_63 x_PM_BUF_X32%4_316 1.95
R_x_PM_BUF_X32%4_r440 x_PM_BUF_X32%4_63 N_4_M22_g 56.94
R_x_PM_BUF_X32%4_r441 x_PM_BUF_X32%4_59 x_PM_BUF_X32%4_316 1.95
R_x_PM_BUF_X32%4_r442 x_PM_BUF_X32%4_59 N_4_M70_g 40.17
R_x_PM_BUF_X32%4_r443 x_PM_BUF_X32%4_55 x_PM_BUF_X32%4_314 1.95
R_x_PM_BUF_X32%4_r444 x_PM_BUF_X32%4_55 N_4_M21_g 56.94
R_x_PM_BUF_X32%4_r445 x_PM_BUF_X32%4_51 x_PM_BUF_X32%4_314 1.95
R_x_PM_BUF_X32%4_r446 x_PM_BUF_X32%4_51 N_4_M69_g 40.17
R_x_PM_BUF_X32%4_r447 x_PM_BUF_X32%4_50 x_PM_BUF_X32%4_312 1.95
R_x_PM_BUF_X32%4_r448 x_PM_BUF_X32%4_49 x_PM_BUF_X32%4_314 1.95
R_x_PM_BUF_X32%4_r449 x_PM_BUF_X32%4_49 x_PM_BUF_X32%4_50 14.56
R_x_PM_BUF_X32%4_r450 x_PM_BUF_X32%4_45 x_PM_BUF_X32%4_312 1.95
R_x_PM_BUF_X32%4_r451 x_PM_BUF_X32%4_45 N_4_M20_g 56.94
R_x_PM_BUF_X32%4_r452 x_PM_BUF_X32%4_41 x_PM_BUF_X32%4_312 1.95
R_x_PM_BUF_X32%4_r453 x_PM_BUF_X32%4_41 N_4_M68_g 40.17
R_x_PM_BUF_X32%4_r454 x_PM_BUF_X32%4_40 x_PM_BUF_X32%4_311 1.95
R_x_PM_BUF_X32%4_r455 x_PM_BUF_X32%4_39 x_PM_BUF_X32%4_312 1.95
R_x_PM_BUF_X32%4_r456 x_PM_BUF_X32%4_39 x_PM_BUF_X32%4_40 14.56
R_x_PM_BUF_X32%4_r457 x_PM_BUF_X32%4_35 x_PM_BUF_X32%4_311 1.95
R_x_PM_BUF_X32%4_r458 x_PM_BUF_X32%4_35 N_4_M19_g 56.94
R_x_PM_BUF_X32%4_r459 x_PM_BUF_X32%4_31 x_PM_BUF_X32%4_311 1.95
R_x_PM_BUF_X32%4_r460 x_PM_BUF_X32%4_31 N_4_M67_g 40.17
R_x_PM_BUF_X32%4_r461 x_PM_BUF_X32%4_30 x_PM_BUF_X32%4_310 1.95
R_x_PM_BUF_X32%4_r462 x_PM_BUF_X32%4_29 x_PM_BUF_X32%4_311 1.95
R_x_PM_BUF_X32%4_r463 x_PM_BUF_X32%4_29 x_PM_BUF_X32%4_30 14.56
R_x_PM_BUF_X32%4_r464 x_PM_BUF_X32%4_25 x_PM_BUF_X32%4_310 1.95
R_x_PM_BUF_X32%4_r465 x_PM_BUF_X32%4_25 N_4_M18_g 56.94
R_x_PM_BUF_X32%4_r466 x_PM_BUF_X32%4_21 x_PM_BUF_X32%4_310 1.95
R_x_PM_BUF_X32%4_r467 x_PM_BUF_X32%4_21 N_4_M66_g 40.17
R_x_PM_BUF_X32%4_r468 x_PM_BUF_X32%4_20 x_PM_BUF_X32%4_309 1.95
R_x_PM_BUF_X32%4_r469 x_PM_BUF_X32%4_19 x_PM_BUF_X32%4_310 1.95
R_x_PM_BUF_X32%4_r470 x_PM_BUF_X32%4_19 x_PM_BUF_X32%4_20 14.56
R_x_PM_BUF_X32%4_r471 x_PM_BUF_X32%4_15 x_PM_BUF_X32%4_309 1.95
R_x_PM_BUF_X32%4_r472 x_PM_BUF_X32%4_15 N_4_M17_g 56.94
R_x_PM_BUF_X32%4_r473 x_PM_BUF_X32%4_11 x_PM_BUF_X32%4_309 1.95
R_x_PM_BUF_X32%4_r474 x_PM_BUF_X32%4_11 N_4_M65_g 40.17
R_x_PM_BUF_X32%4_r475 x_PM_BUF_X32%4_10 x_PM_BUF_X32%4_450 0.043368
R_x_PM_BUF_X32%4_r476 x_PM_BUF_X32%4_9 x_PM_BUF_X32%4_309 1.95
R_x_PM_BUF_X32%4_r477 x_PM_BUF_X32%4_9 x_PM_BUF_X32%4_10 16.64
R_x_PM_BUF_X32%4_r478 x_PM_BUF_X32%4_5 x_PM_BUF_X32%4_450 4.56151
R_x_PM_BUF_X32%4_r479 x_PM_BUF_X32%4_5 N_4_M16_g 56.94
R_x_PM_BUF_X32%4_r480 Z_neg x_PM_BUF_X32%4_450 4.56151
R_x_PM_BUF_X32%4_r481 Z_neg N_4_M64_g 40.17
C_x_PM_BUF_X32%Z_c0 N_Z_M94_d VSS 4.7011e-17
C_x_PM_BUF_X32%Z_c1 N_Z_M92_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c2 N_Z_M90_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c3 N_Z_M88_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c4 N_Z_M86_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c5 N_Z_M84_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c6 N_Z_M82_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c7 N_Z_M80_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c8 N_Z_M78_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c9 N_Z_M76_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c10 N_Z_M74_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c11 N_Z_M72_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c12 N_Z_M70_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c13 N_Z_M68_d VSS 3.12457e-17
C_x_PM_BUF_X32%Z_c14 N_Z_M66_d VSS 3.12088e-17
C_x_PM_BUF_X32%Z_c15 N_Z_M64_d VSS 4.6185e-17
C_x_PM_BUF_X32%Z_c16 N_Z_M46_d VSS 1.38009e-16
C_x_PM_BUF_X32%Z_c17 x_PM_BUF_X32%Z_153 VSS 5.036e-17
C_x_PM_BUF_X32%Z_c18 N_Z_M44_d VSS 7.2741e-17
C_x_PM_BUF_X32%Z_c19 x_PM_BUF_X32%Z_145 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c20 N_Z_M42_d VSS 4.06114e-17
C_x_PM_BUF_X32%Z_c21 x_PM_BUF_X32%Z_137 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c22 N_Z_M40_d VSS 5.51945e-17
C_x_PM_BUF_X32%Z_c23 x_PM_BUF_X32%Z_129 VSS 5.06455e-17
C_x_PM_BUF_X32%Z_c24 N_Z_M38_d VSS 7.27388e-17
C_x_PM_BUF_X32%Z_c25 x_PM_BUF_X32%Z_121 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c26 N_Z_M36_d VSS 4.05792e-17
C_x_PM_BUF_X32%Z_c27 x_PM_BUF_X32%Z_113 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c28 N_Z_M34_d VSS 5.51623e-17
C_x_PM_BUF_X32%Z_c29 x_PM_BUF_X32%Z_105 VSS 5.06455e-17
C_x_PM_BUF_X32%Z_c30 N_Z_M32_d VSS 7.27388e-17
C_x_PM_BUF_X32%Z_c31 x_PM_BUF_X32%Z_95 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c32 N_Z_M30_d VSS 4.05792e-17
C_x_PM_BUF_X32%Z_c33 x_PM_BUF_X32%Z_87 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c34 N_Z_M28_d VSS 5.51623e-17
C_x_PM_BUF_X32%Z_c35 x_PM_BUF_X32%Z_79 VSS 5.06455e-17
C_x_PM_BUF_X32%Z_c36 N_Z_M26_d VSS 7.27388e-17
C_x_PM_BUF_X32%Z_c37 x_PM_BUF_X32%Z_71 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c38 N_Z_M24_d VSS 4.05792e-17
C_x_PM_BUF_X32%Z_c39 x_PM_BUF_X32%Z_63 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c40 N_Z_M22_d VSS 5.51623e-17
C_x_PM_BUF_X32%Z_c41 x_PM_BUF_X32%Z_55 VSS 5.06455e-17
C_x_PM_BUF_X32%Z_c42 N_Z_M20_d VSS 7.27388e-17
C_x_PM_BUF_X32%Z_c43 x_PM_BUF_X32%Z_47 VSS 4.56887e-17
C_x_PM_BUF_X32%Z_c44 N_Z_M18_d VSS 4.04753e-17
C_x_PM_BUF_X32%Z_c45 x_PM_BUF_X32%Z_39 VSS 4.46244e-17
C_x_PM_BUF_X32%Z_c46 N_Z_M16_d VSS 9.25795e-17
R_x_PM_BUF_X32%Z_r47 x_PM_BUF_X32%Z_157 N_Z_M94_d 0.273842
R_x_PM_BUF_X32%Z_r48 x_PM_BUF_X32%Z_157 N_Z_M46_d 4.13929
R_x_PM_BUF_X32%Z_r49 x_PM_BUF_X32%Z_154 N_Z_M92_d 0.0950001
R_x_PM_BUF_X32%Z_r50 x_PM_BUF_X32%Z_153 N_Z_M94_d 0.0307623
R_x_PM_BUF_X32%Z_r51 x_PM_BUF_X32%Z_153 x_PM_BUF_X32%Z_154 0.841429
R_x_PM_BUF_X32%Z_r52 x_PM_BUF_X32%Z_149 N_Z_M92_d 0.0950001
R_x_PM_BUF_X32%Z_r53 x_PM_BUF_X32%Z_149 N_Z_M44_d 1.615
R_x_PM_BUF_X32%Z_r54 x_PM_BUF_X32%Z_146 N_Z_M90_d 0.0950001
R_x_PM_BUF_X32%Z_r55 x_PM_BUF_X32%Z_145 N_Z_M92_d 0.0950001
R_x_PM_BUF_X32%Z_r56 x_PM_BUF_X32%Z_145 x_PM_BUF_X32%Z_146 0.841429
R_x_PM_BUF_X32%Z_r57 x_PM_BUF_X32%Z_141 N_Z_M90_d 0.0950001
R_x_PM_BUF_X32%Z_r58 x_PM_BUF_X32%Z_141 N_Z_M42_d 1.615
R_x_PM_BUF_X32%Z_r59 x_PM_BUF_X32%Z_138 N_Z_M88_d 0.0950001
R_x_PM_BUF_X32%Z_r60 x_PM_BUF_X32%Z_137 N_Z_M90_d 0.0950001
R_x_PM_BUF_X32%Z_r61 x_PM_BUF_X32%Z_137 x_PM_BUF_X32%Z_138 0.841429
R_x_PM_BUF_X32%Z_r62 x_PM_BUF_X32%Z_133 N_Z_M88_d 0.0950001
R_x_PM_BUF_X32%Z_r63 x_PM_BUF_X32%Z_133 N_Z_M40_d 1.615
R_x_PM_BUF_X32%Z_r64 x_PM_BUF_X32%Z_130 N_Z_M86_d 0.0950001
R_x_PM_BUF_X32%Z_r65 x_PM_BUF_X32%Z_129 N_Z_M88_d 0.0950001
R_x_PM_BUF_X32%Z_r66 x_PM_BUF_X32%Z_129 x_PM_BUF_X32%Z_130 0.841429
R_x_PM_BUF_X32%Z_r67 x_PM_BUF_X32%Z_125 N_Z_M86_d 0.0950001
R_x_PM_BUF_X32%Z_r68 x_PM_BUF_X32%Z_125 N_Z_M38_d 1.615
R_x_PM_BUF_X32%Z_r69 x_PM_BUF_X32%Z_122 N_Z_M84_d 0.0950001
R_x_PM_BUF_X32%Z_r70 x_PM_BUF_X32%Z_121 N_Z_M86_d 0.0950001
R_x_PM_BUF_X32%Z_r71 x_PM_BUF_X32%Z_121 x_PM_BUF_X32%Z_122 0.841429
R_x_PM_BUF_X32%Z_r72 x_PM_BUF_X32%Z_117 N_Z_M84_d 0.0950001
R_x_PM_BUF_X32%Z_r73 x_PM_BUF_X32%Z_117 N_Z_M36_d 1.615
R_x_PM_BUF_X32%Z_r74 x_PM_BUF_X32%Z_114 N_Z_M82_d 0.0950001
R_x_PM_BUF_X32%Z_r75 x_PM_BUF_X32%Z_113 N_Z_M84_d 0.0950001
R_x_PM_BUF_X32%Z_r76 x_PM_BUF_X32%Z_113 x_PM_BUF_X32%Z_114 0.841429
R_x_PM_BUF_X32%Z_r77 x_PM_BUF_X32%Z_109 N_Z_M82_d 0.0950001
R_x_PM_BUF_X32%Z_r78 x_PM_BUF_X32%Z_109 N_Z_M34_d 1.615
R_x_PM_BUF_X32%Z_r79 x_PM_BUF_X32%Z_106 N_Z_M80_d 0.0950001
R_x_PM_BUF_X32%Z_r80 x_PM_BUF_X32%Z_105 N_Z_M82_d 0.0950001
R_x_PM_BUF_X32%Z_r81 x_PM_BUF_X32%Z_105 x_PM_BUF_X32%Z_106 0.841429
R_x_PM_BUF_X32%Z_r82 x_PM_BUF_X32%Z_101 N_Z_M80_d 0.0950001
R_x_PM_BUF_X32%Z_r83 x_PM_BUF_X32%Z_101 N_Z_M32_d 1.615
R_x_PM_BUF_X32%Z_r84 x_PM_BUF_X32%Z_96 N_Z_M78_d 0.0950001
R_x_PM_BUF_X32%Z_r85 x_PM_BUF_X32%Z_96 Z 0.420714
R_x_PM_BUF_X32%Z_r86 x_PM_BUF_X32%Z_95 N_Z_M80_d 0.0950001
R_x_PM_BUF_X32%Z_r87 x_PM_BUF_X32%Z_95 Z 0.420714
R_x_PM_BUF_X32%Z_r88 x_PM_BUF_X32%Z_91 N_Z_M78_d 0.0950001
R_x_PM_BUF_X32%Z_r89 x_PM_BUF_X32%Z_91 N_Z_M30_d 1.615
R_x_PM_BUF_X32%Z_r90 x_PM_BUF_X32%Z_88 N_Z_M76_d 0.0950001
R_x_PM_BUF_X32%Z_r91 x_PM_BUF_X32%Z_87 N_Z_M78_d 0.0950001
R_x_PM_BUF_X32%Z_r92 x_PM_BUF_X32%Z_87 x_PM_BUF_X32%Z_88 0.841429
R_x_PM_BUF_X32%Z_r93 x_PM_BUF_X32%Z_83 N_Z_M76_d 0.0950001
R_x_PM_BUF_X32%Z_r94 x_PM_BUF_X32%Z_83 N_Z_M28_d 1.615
R_x_PM_BUF_X32%Z_r95 x_PM_BUF_X32%Z_80 N_Z_M74_d 0.0950001
R_x_PM_BUF_X32%Z_r96 x_PM_BUF_X32%Z_79 N_Z_M76_d 0.0950001
R_x_PM_BUF_X32%Z_r97 x_PM_BUF_X32%Z_79 x_PM_BUF_X32%Z_80 0.841429
R_x_PM_BUF_X32%Z_r98 x_PM_BUF_X32%Z_75 N_Z_M74_d 0.0950001
R_x_PM_BUF_X32%Z_r99 x_PM_BUF_X32%Z_75 N_Z_M26_d 1.615
R_x_PM_BUF_X32%Z_r100 x_PM_BUF_X32%Z_72 N_Z_M72_d 0.0950001
R_x_PM_BUF_X32%Z_r101 x_PM_BUF_X32%Z_71 N_Z_M74_d 0.0950001
R_x_PM_BUF_X32%Z_r102 x_PM_BUF_X32%Z_71 x_PM_BUF_X32%Z_72 0.841429
R_x_PM_BUF_X32%Z_r103 x_PM_BUF_X32%Z_67 N_Z_M72_d 0.0950001
R_x_PM_BUF_X32%Z_r104 x_PM_BUF_X32%Z_67 N_Z_M24_d 1.615
R_x_PM_BUF_X32%Z_r105 x_PM_BUF_X32%Z_64 N_Z_M70_d 0.0950001
R_x_PM_BUF_X32%Z_r106 x_PM_BUF_X32%Z_63 N_Z_M72_d 0.0950001
R_x_PM_BUF_X32%Z_r107 x_PM_BUF_X32%Z_63 x_PM_BUF_X32%Z_64 0.841429
R_x_PM_BUF_X32%Z_r108 x_PM_BUF_X32%Z_59 N_Z_M70_d 0.0950001
R_x_PM_BUF_X32%Z_r109 x_PM_BUF_X32%Z_59 N_Z_M22_d 1.615
R_x_PM_BUF_X32%Z_r110 x_PM_BUF_X32%Z_56 N_Z_M68_d 0.0950001
R_x_PM_BUF_X32%Z_r111 x_PM_BUF_X32%Z_55 N_Z_M70_d 0.0950001
R_x_PM_BUF_X32%Z_r112 x_PM_BUF_X32%Z_55 x_PM_BUF_X32%Z_56 0.841429
R_x_PM_BUF_X32%Z_r113 x_PM_BUF_X32%Z_51 N_Z_M68_d 0.0950001
R_x_PM_BUF_X32%Z_r114 x_PM_BUF_X32%Z_51 N_Z_M20_d 1.615
R_x_PM_BUF_X32%Z_r115 x_PM_BUF_X32%Z_48 N_Z_M66_d 0.0950001
R_x_PM_BUF_X32%Z_r116 x_PM_BUF_X32%Z_47 N_Z_M68_d 0.0950001
R_x_PM_BUF_X32%Z_r117 x_PM_BUF_X32%Z_47 x_PM_BUF_X32%Z_48 0.841429
R_x_PM_BUF_X32%Z_r118 x_PM_BUF_X32%Z_43 N_Z_M66_d 0.0950001
R_x_PM_BUF_X32%Z_r119 x_PM_BUF_X32%Z_43 N_Z_M18_d 1.615
R_x_PM_BUF_X32%Z_r120 x_PM_BUF_X32%Z_40 N_Z_M64_d 0.0307623
R_x_PM_BUF_X32%Z_r121 x_PM_BUF_X32%Z_39 N_Z_M66_d 0.0950001
R_x_PM_BUF_X32%Z_r122 x_PM_BUF_X32%Z_39 x_PM_BUF_X32%Z_40 0.814286
R_x_PM_BUF_X32%Z_r123 x_PM_BUF_X32%Z_35 N_Z_M64_d 0.273842
R_x_PM_BUF_X32%Z_r124 x_PM_BUF_X32%Z_35 N_Z_M16_d 1.615
.ENDS

********************************************************************************
*
* END
*
********************************************************************************
